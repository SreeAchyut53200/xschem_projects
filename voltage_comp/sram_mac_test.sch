v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {voltage_comp/comp_1bit.sym} 290 -400 0 1 {name=xfull_comp[1..8]}
C {iopin.sym} 100 -670 0 1 {name=p2 lab=VSS}
C {iopin.sym} 100 -690 0 1 {name=p9 lab=VCC}
C {iopin.sym} 100 -650 0 1 {name=p10 lab=CLK}
C {iopin.sym} 100 -630 0 1 {name=p11 lab=CLK_bar}
C {lab_pin.sym} 100 -690 0 1 {name=p7 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -670 0 1 {name=p14 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 100 -650 0 1 {name=p17 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 100 -630 0 1 {name=p18 sig_type=std_logic lab=CLK_bar
}
C {iopin.sym} 100 -590 0 1 {name=p19 lab=Q}
C {iopin.sym} 100 -570 0 1 {name=p20 lab=Q_bar}
C {lab_pin.sym} 100 -570 0 1 {name=p21 sig_type=std_logic lab=Q_bar}
C {lab_pin.sym} 100 -590 0 1 {name=p22 sig_type=std_logic lab=Q}
C {iopin.sym} 100 -550 0 1 {name=p8 lab=EN}
C {lab_pin.sym} 100 -550 0 1 {name=p12 sig_type=std_logic lab=EN}
C {lab_pin.sym} 140 -480 0 0 {name=p23 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 140 -460 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 140 -440 0 0 {name=p27 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 140 -420 0 0 {name=p28 sig_type=std_logic lab=CLK_bar
}
C {lab_pin.sym} 140 -320 0 0 {name=p36 sig_type=std_logic lab=EN}
C {iopin.sym} 100 -610 0 1 {name=p1 lab=MAC[1..8]}
C {lab_pin.sym} 100 -610 0 1 {name=p3 sig_type=std_logic lab=MAC[1..8]}
C {lab_pin.sym} 140 -380 0 0 {name=p4 sig_type=std_logic lab=TR[1..8]}
C {lab_pin.sym} 140 -360 0 0 {name=p5 sig_type=std_logic lab=MAC[1..8]}
C {lab_pin.sym} 100 -530 0 1 {name=p6 sig_type=std_logic lab=TR[1..8]}
C {iopin.sym} 100 -530 0 1 {name=p13 lab=TR[1..8]}
C {lab_pin.sym} 140 -400 0 0 {name=p15 sig_type=std_logic lab=IN}
