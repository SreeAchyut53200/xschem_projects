v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {voltage_comp/dt_comp&rs_latch.sym} 180 140 0 0 {name=x[8..0]}
C {iopin.sym} 171.4568575726846 -320 0 0 {name=p78 lab=VCC}
C {iopin.sym} 171.4568575726846 -300 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 171.4568575726846 -300 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 171.4568575726846 -320 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 171.4568575726846 -130 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 171.4568575726846 -130 0 0 {name=p83 sig_type=std_logic lab=EN}
C {iopin.sym} 171.4568575726846 -270 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 171.4568575726846 -270 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 171.4568575726846 -250 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 171.4568575726846 -250 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 171.4568575726846 -110 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 171.4568575726846 -110 0 0 {name=p136 lab=EN_bar}
C {lab_pin.sym} 330 70 0 1 {name=p1 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 330 50 0 1 {name=p2 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 330 90 0 1 {name=p3 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 330 110 0 1 {name=p4 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 330 210 0 1 {name=p5 sig_type=std_logic lab=EN}
C {lab_pin.sym} 330 230 0 1 {name=p6 lab=EN_bar}
C {lab_pin.sym} 170 -210 0 0 {name=p12 sig_type=std_logic lab=IN1[8..0]}
C {iopin.sym} 170 -210 0 0 {name=p7 lab=IN1[8..0]}
C {lab_pin.sym} 170 -170 0 0 {name=p8 sig_type=std_logic lab=Q[8..0]}
C {iopin.sym} 170 -170 0 0 {name=p9 lab=Q[8..0]}
C {lab_pin.sym} 170 -190 0 0 {name=p16 sig_type=std_logic lab=IN2[8..0]}
C {iopin.sym} 170 -190 0 0 {name=p17 lab=IN2[8..0]}
C {lab_pin.sym} 170 -150 0 0 {name=p10 sig_type=std_logic lab=Q_bar[8..0]}
C {iopin.sym} 170 -150 0 0 {name=p11 lab=Q_bar[8..0]}
C {lab_pin.sym} 330 130 0 1 {name=p13 sig_type=std_logic lab=IN1[8..0]}
C {lab_pin.sym} 330 150 0 1 {name=p15 sig_type=std_logic lab=IN2[8..0]}
C {lab_pin.sym} 330 170 0 1 {name=p14 sig_type=std_logic lab=Q[8..0]}
C {lab_pin.sym} 330 190 0 1 {name=p18 sig_type=std_logic lab=Q_bar[8..0]}
