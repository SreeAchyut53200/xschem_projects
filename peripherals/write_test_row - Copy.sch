v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -940 -2980 -140 -2580 {flags=graph
y1=-0.027
y2=1.9
ypos1=1.61095
ypos2=3.53795
divy=5
subdivy=1
unity=1
x1=-5.2227465e+306
x2=1.5668241e+307
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row.raw
autoload=0
digital=1
legend=1
color="4 5 6 7 8 9 10 20 4 4 4 4 4 4 4 4"
node="x8.q
x7.q
x6.q
x5.q
x4.q
x3.q
x2.q
x1.q
x8.q_bar
x7.q_bar
x6.q_bar
x5.q_bar
x4.q_bar
x3.q_bar
x2.q_bar
x1.q_bar"
sim_type=tran}
B 2 -1760 -2980 -960 -2580 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.4124
ypos2=1.5146
divy=5
subdivy=1
unity=1
x1=5.2227464e+306
x2=2.6113731e+307
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row.raw
autoload=0
digital=1
color="4 5 6 7 8 9"
node="s2
s1
s0
en
pre
rwl"
hilight_wave=-1}
B 2 -1760 -2440 -960 -2040 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.2227464e+306
x2=2.6113731e+307
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row.raw
autoload=0
digital=1
color="4 5 6 7 8 9 10 11"
node="bl7
bl6
bl5
bl4
bl3
bl2
bl1
bl0"
hilight_wave=-1}
B 2 -940 -2440 -140 -2040 {flags=graph
y1=-3.4e+249
y2=2.1e+307
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.2227464e+306
x2=2.6113731e+307
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row.raw
autoload=0
digital=0
hilight_wave=2
color="4 5 6"
node="pre
rwl
rbl7"}
B 4 170 -5120 3480 -3910 {fill=false}
N 940 -3210 940 -3120 {lab=RBL0}
N 940 -3150 990 -3150 {lab=RBL0}
N 940 -3290 940 -3270 {lab=GND}
N 940 -3240 950 -3240 {lab=GND}
N 950 -3280 950 -3240 {lab=GND}
N 940 -3280 950 -3280 {lab=GND}
N 880 -3240 900 -3240 {lab=PRE}
N 850 -2250 3120 -2250 {lab=BL[0..7]
bus=true}
N 850 -2200 3120 -2200 {lab=BLB[0..7]
bus=true}
N 880 -2190 880 -2080 {lab=BLB0}
N 880 -2080 940 -2080 {lab=BLB0}
N 860 -2240 860 -2060 {lab=BL0
bus}
N 860 -2060 940 -2060 {lab=BL0}
N 1170 -2190 1170 -2080 {lab=BLB1}
N 1170 -2080 1230 -2080 {lab=BLB1}
N 1150 -2240 1150 -2060 {lab=BL1}
N 1150 -2060 1230 -2060 {lab=BL1}
N 1460 -2190 1460 -2080 {lab=BLB2}
N 1460 -2080 1520 -2080 {lab=BLB2}
N 1440 -2240 1440 -2060 {lab=BL2}
N 1440 -2060 1520 -2060 {lab=BL2}
N 1750 -2190 1750 -2080 {lab=BLB3}
N 1750 -2080 1810 -2080 {lab=BLB3}
N 1730 -2240 1730 -2060 {lab=BL3}
N 1730 -2060 1810 -2060 {lab=BL3}
N 2040 -2190 2040 -2080 {lab=BLB4}
N 2040 -2080 2100 -2080 {lab=BLB4}
N 2020 -2240 2020 -2060 {lab=BL4}
N 2020 -2060 2100 -2060 {lab=BL4}
N 2330 -2190 2330 -2080 {lab=BLB5}
N 2330 -2080 2390 -2080 {lab=BLB5}
N 2310 -2240 2310 -2060 {lab=BL5}
N 2310 -2060 2390 -2060 {lab=BL5}
N 2620 -2190 2620 -2080 {lab=BLB6}
N 2620 -2080 2680 -2080 {lab=BLB6}
N 2600 -2240 2600 -2060 {lab=BL6}
N 2600 -2060 2680 -2060 {lab=BL6}
N 2910 -2190 2910 -2080 {lab=BLB7}
N 2910 -2080 2970 -2080 {lab=BLB7}
N 2890 -2240 2890 -2060 {lab=BL7}
N 2890 -2060 2970 -2060 {lab=BL7}
N 200 -1670 200 -1480 {lab=WL[0..7]
bus=true}
N 150 -1640 190 -1640 {lab=WL7}
N 150 -1620 190 -1620 {lab=WL6}
N 150 -1600 190 -1600 {lab=WL5}
N 150 -1580 190 -1580 {lab=WL4}
N 150 -1560 190 -1560 {lab=WL3}
N 150 -1540 190 -1540 {lab=WL2}
N 150 -1520 190 -1520 {lab=WL1}
N 150 -1500 190 -1500 {lab=WL0}
N 860 -2060 860 -1810 {lab=BL0}
N 860 -1810 940 -1810 {lab=BL0}
N 880 -2080 880 -1830 {lab=BLB0}
N 880 -1830 940 -1830 {lab=BLB0}
N 1150 -2060 1150 -1810 {lab=BL1}
N 1150 -1810 1230 -1810 {lab=BL1}
N 1170 -2080 1170 -1830 {lab=BLB1}
N 1170 -1830 1230 -1830 {lab=BLB1}
N 1440 -2060 1440 -1810 {lab=BL2}
N 1440 -1810 1520 -1810 {lab=BL2}
N 1460 -2080 1460 -1830 {lab=BLB2}
N 1460 -1830 1520 -1830 {lab=BLB2}
N 1730 -2060 1730 -1810 {lab=BL3}
N 1730 -1810 1810 -1810 {lab=BL3}
N 1750 -2080 1750 -1830 {lab=BLB3}
N 1750 -1830 1810 -1830 {lab=BLB3}
N 2020 -2060 2020 -1810 {lab=BL4}
N 2020 -1810 2100 -1810 {lab=BL4}
N 2040 -2080 2040 -1830 {lab=BLB4}
N 2040 -1830 2100 -1830 {lab=BLB4}
N 2310 -2060 2310 -1810 {lab=BL5}
N 2310 -1810 2390 -1810 {lab=BL5}
N 2330 -2080 2330 -1830 {lab=BLB5}
N 2330 -1830 2390 -1830 {lab=BLB5}
N 2600 -2060 2600 -1810 {lab=BL6}
N 2600 -1810 2680 -1810 {lab=BL6}
N 2620 -2080 2620 -1830 {lab=BLB6}
N 2620 -1830 2680 -1830 {lab=BLB6}
N 2890 -2060 2890 -1810 {lab=BL7}
N 2890 -1810 2970 -1810 {lab=BL7}
N 2910 -2080 2910 -1830 {lab=BLB7}
N 2910 -1830 2970 -1830 {lab=BLB7}
N 1230 -3210 1230 -3120 {lab=RBL1}
N 1230 -3150 1280 -3150 {lab=RBL1}
N 1230 -3290 1230 -3270 {lab=GND}
N 1230 -3240 1240 -3240 {lab=GND}
N 1240 -3280 1240 -3240 {lab=GND}
N 1230 -3280 1240 -3280 {lab=GND}
N 1170 -3240 1190 -3240 {lab=PRE}
N 1520 -3210 1520 -3120 {lab=RBL2}
N 1520 -3150 1570 -3150 {lab=RBL2}
N 1520 -3290 1520 -3270 {lab=GND}
N 1520 -3240 1530 -3240 {lab=GND}
N 1530 -3280 1530 -3240 {lab=GND}
N 1520 -3280 1530 -3280 {lab=GND}
N 1460 -3240 1480 -3240 {lab=PRE}
N 1810 -3210 1810 -3120 {lab=RBL3}
N 1810 -3290 1810 -3270 {lab=GND}
N 1810 -3240 1820 -3240 {lab=GND}
N 1820 -3280 1820 -3240 {lab=GND}
N 1810 -3280 1820 -3280 {lab=GND}
N 1750 -3240 1770 -3240 {lab=PRE}
N 2100 -3210 2100 -3120 {lab=RBL4}
N 2100 -3150 2150 -3150 {lab=RBL4}
N 2100 -3290 2100 -3270 {lab=GND}
N 2100 -3240 2110 -3240 {lab=GND}
N 2110 -3280 2110 -3240 {lab=GND}
N 2100 -3280 2110 -3280 {lab=GND}
N 2040 -3240 2060 -3240 {lab=PRE}
N 2390 -3210 2390 -3120 {lab=RBL5}
N 2390 -3150 2440 -3150 {lab=RBL5}
N 2390 -3290 2390 -3270 {lab=GND}
N 2390 -3240 2400 -3240 {lab=GND}
N 2400 -3280 2400 -3240 {lab=GND}
N 2390 -3280 2400 -3280 {lab=GND}
N 2330 -3240 2350 -3240 {lab=PRE}
N 2680 -3210 2680 -3120 {lab=RBL6}
N 2680 -3150 2730 -3150 {lab=RBL6}
N 2680 -3290 2680 -3270 {lab=GND}
N 2680 -3240 2690 -3240 {lab=GND}
N 2690 -3280 2690 -3240 {lab=GND}
N 2680 -3280 2690 -3280 {lab=GND}
N 2620 -3240 2640 -3240 {lab=PRE}
N 2970 -3210 2970 -3120 {lab=RBL7}
N 2970 -3150 3020 -3150 {lab=RBL7}
N 2970 -3290 2970 -3270 {lab=GND}
N 2970 -3240 2980 -3240 {lab=GND}
N 2980 -3280 2980 -3240 {lab=GND}
N 2970 -3280 2980 -3280 {lab=GND}
N 2910 -3240 2930 -3240 {lab=PRE}
N 1810 -3150 1860 -3150 {lab=RBL3}
N 860 -1200 940 -1200 {lab=MAC2_barC0}
N 880 -1220 940 -1220 {lab=MAC1C0}
N 1150 -1200 1230 -1200 {lab=MAC2_barC1}
N 1170 -1220 1230 -1220 {lab=MAC1C1}
N 1440 -1200 1520 -1200 {lab=MAC2_barC2}
N 1460 -1220 1520 -1220 {lab=MAC1C2}
N 1730 -1200 1810 -1200 {lab=MAC2_barC3}
N 1750 -1220 1810 -1220 {lab=MAC1C3}
N 2020 -1200 2100 -1200 {lab=MAC2_barC4}
N 2040 -1220 2100 -1220 {lab=MAC1C4}
N 2310 -1200 2390 -1200 {lab=MAC2_barC5}
N 2330 -1220 2390 -1220 {lab=MAC1C5}
N 2600 -1200 2680 -1200 {lab=MAC2_barC6}
N 2620 -1220 2680 -1220 {lab=MAC1C6}
N 2890 -1200 2970 -1200 {lab=MAC2_barC7}
N 2910 -1220 2970 -1220 {lab=MAC1C7}
N 3530 -1510 3530 -1420 {lab=MACRBL}
N 3530 -1450 3580 -1450 {lab=MACRBL}
N 3530 -1590 3530 -1570 {lab=GND}
N 3530 -1540 3540 -1540 {lab=GND}
N 3540 -1580 3540 -1540 {lab=GND}
N 3530 -1580 3540 -1580 {lab=GND}
N 3470 -1540 3490 -1540 {lab=PRE}
N 900 -4830 3020 -4830 {lab=ABC[0..7]_bar
bus=true}
N 830 -1480 2950 -1480 {lab=MAC1C[0..7]
bus=true}
N 880 -1470 880 -1220 {lab=MAC1C0}
N 1170 -1470 1170 -1220 {lab=MAC1C1}
N 1460 -1470 1460 -1220 {lab=MAC1C2}
N 1750 -1470 1750 -1220 {lab=MAC1C3}
N 2040 -1470 2040 -1220 {lab=MAC1C4}
N 2330 -1470 2330 -1220 {lab=MAC1C5}
N 2620 -1470 2620 -1220 {lab=MAC1C6}
N 2910 -1470 2910 -1220 {lab=MAC1C7}
N 720 -1320 2930 -1320 {lab=MAC2_barC[0..7]
bus=true}
N 860 -1310 860 -1200 {lab=MAC2_barC0}
N 1150 -1310 1150 -1200 {lab=MAC2_barC1}
N 1440 -1310 1440 -1200 {lab=MAC2_barC2}
N 1730 -1310 1730 -1200 {lab=MAC2_barC3}
N 2020 -1310 2020 -1200 {lab=MAC2_barC4}
N 2310 -1310 2310 -1200 {lab=MAC2_barC5}
N 2600 -1310 2600 -1200 {lab=MAC2_barC6}
N 2890 -1310 2890 -1200 {lab=MAC2_barC7}
N 810 -1270 810 -1220 {lab=MAC2_barC[0..7]}
N 810 -1320 810 -1270 {lab=MAC2_barC[0..7]}
C {iopin.sym} 110 -2040 0 0 {name=p7 lab=WL[0..7]}
C {lab_pin.sym} 110 -2040 0 0 {name=p18 sig_type=std_logic lab=WL[0..7]}
C {lab_pin.sym} 940 -2100 0 0 {name=p1 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 940 -2000 0 0 {name=p43 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -2120 0 0 {name=p51 sig_type=std_logic lab=VCC}
C {code.sym} -1330 -1760 0 0 {
name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
spice_ignore=false
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
"
spice_ignore=false
      }
C {code_shown.sym} -1200 -1890 0 0 {name=s2 only_toplevel=false spice_ignore=false value=
"
.param VCC=1.8 VSS=0

V_VCC VCC 0 DC 1.8
V_VSS VSS 0 DC 0
"}
C {iopin.sym} 110 -1950 0 0 {name=p69 lab=S2}
C {iopin.sym} 110 -1930 0 0 {name=p70 lab=S1}
C {iopin.sym} 110 -1910 0 0 {name=p71 lab=S0}
C {lab_pin.sym} 110 -1950 0 0 {name=p72 sig_type=std_logic lab=S2}
C {lab_pin.sym} 110 -1930 0 0 {name=p73 sig_type=std_logic lab=S1}
C {lab_pin.sym} 110 -1910 0 0 {name=p74 sig_type=std_logic lab=S0}
C {iopin.sym} 110 -2310 0 0 {name=p78 lab=VCC}
C {iopin.sym} 110 -2290 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 110 -2290 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 110 -2310 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -2150 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 110 -2150 0 0 {name=p83 sig_type=std_logic lab=EN}
C {code_shown.sym} -480 -1590 0 1 {name=s3 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=8 pre_time=6ns read_time=2ns write_delay=10ns 


*V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
V_BLB0 BL0 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL1 BLB1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
V_BLB1 BL1 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})

V_BL2 BLB2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})
V_BLB2 BL2 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_BL3 BLB3 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})
V_BLB3 BL3 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})

V_BL4 BLB4 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})
V_BLB4 BL4 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})

V_BL5 BLB5 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})
V_BLB5 BL5 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})

V_BL6 BLB6 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})
V_BLB6 BL6 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})

V_BL7 BLB7 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})
V_BLB7 BL7 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds*2\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds*2\})

.tran 0.01ns \{BL_period*2*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {launcher.sym} -840 -2540 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/write_test_row.raw tran"
}
C {8T_sram_cell_c.sym} 3120 -2060 0 1 {name=x8}
C {lab_pin.sym} 940 -2020 0 0 {name=p87 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -2040 0 0 {name=p103 sig_type=std_logic lab=RBL7}
C {iopin.sym} 110 -1880 0 0 {name=p89 lab=RBL[0..7]}
C {iopin.sym} 110 -1860 0 0 {name=p90 lab=RWL}
C {lab_pin.sym} 110 -1880 0 0 {name=p91 sig_type=std_logic lab=RBL[0..7]}
C {lab_pin.sym} 110 -1860 0 0 {name=p92 sig_type=std_logic lab=RWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 940 -3090 0 0 {name=C2 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 940 -3290 2 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 920 -3240 2 1 {name=M2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 940 -3060 0 1 {name=l10 lab=GND}
C {iopin.sym} 110 -1840 0 0 {name=p93 lab=PRE}
C {lab_pin.sym} 110 -1840 0 0 {name=p95 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 880 -3240 0 0 {name=p96 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 1230 -2100 0 0 {name=p2 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1230 -2000 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1230 -2120 0 0 {name=p6 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1090 -2060 0 1 {name=x1}
C {lab_pin.sym} 1230 -2020 0 0 {name=p15 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -2040 0 0 {name=p16 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 1520 -2100 0 0 {name=p28 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1520 -2000 0 0 {name=p31 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1520 -2120 0 0 {name=p32 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1380 -2060 0 1 {name=x2}
C {lab_pin.sym} 1520 -2020 0 0 {name=p33 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -2040 0 0 {name=p34 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 1810 -2100 0 0 {name=p36 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1810 -2000 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1810 -2120 0 0 {name=p40 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1670 -2060 0 1 {name=x3}
C {lab_pin.sym} 1810 -2020 0 0 {name=p41 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -2040 0 0 {name=p42 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -2100 0 0 {name=p44 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2100 -2000 0 0 {name=p47 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -2120 0 0 {name=p48 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1960 -2060 0 1 {name=x4}
C {lab_pin.sym} 2100 -2020 0 0 {name=p49 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -2040 0 0 {name=p52 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 2390 -2100 0 0 {name=p53 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2390 -2000 0 0 {name=p56 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2390 -2120 0 0 {name=p57 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2250 -2060 0 1 {name=x5}
C {lab_pin.sym} 2390 -2020 0 0 {name=p58 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -2040 0 0 {name=p88 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 2680 -2100 0 0 {name=p97 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2680 -2000 0 0 {name=p100 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2680 -2120 0 0 {name=p101 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2540 -2060 0 1 {name=x6}
C {lab_pin.sym} 2680 -2020 0 0 {name=p104 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -2040 0 0 {name=p105 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 2970 -2100 0 0 {name=p106 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2970 -2000 0 0 {name=p109 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2970 -2120 0 0 {name=p110 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2830 -2060 0 1 {name=x7}
C {lab_pin.sym} 2970 -2020 0 0 {name=p111 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -2040 0 0 {name=p112 sig_type=std_logic lab=RBL0}
C {iopin.sym} 110 -2010 0 0 {name=p17 lab=BL[0..7]}
C {lab_pin.sym} 110 -2010 0 0 {name=p26 sig_type=std_logic lab=BL[0..7]}
C {iopin.sym} 110 -1990 0 0 {name=p59 lab=BLB[0..7]}
C {lab_pin.sym} 110 -1990 0 0 {name=p60 sig_type=std_logic lab=BLB[0..7]}
C {logic gates/decoder.sym} 100 -1570 0 0 {name=x77}
C {lab_pin.sym} 40 -1590 0 0 {name=p75 sig_type=std_logic lab=S2}
C {lab_pin.sym} 40 -1570 0 0 {name=p76 sig_type=std_logic lab=S1}
C {lab_pin.sym} 40 -1550 0 0 {name=p77 sig_type=std_logic lab=S0}
C {lab_pin.sym} 40 -1520 0 0 {name=p84 sig_type=std_logic lab=EN}
C {lab_pin.sym} 100 -1660 0 0 {name=p85 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -1480 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {bus_tap.sym} 850 -2250 1 0 {name=l2 lab=0}
C {lab_pin.sym} 850 -2250 0 0 {name=p3 sig_type=std_logic lab=BL[0..7]}
C {lab_pin.sym} 850 -2200 0 0 {name=p4 sig_type=std_logic lab=BLB[0..7]}
C {bus_tap.sym} 870 -2200 1 0 {name=l3 lab=0}
C {bus_tap.sym} 1140 -2250 1 0 {name=l4 lab=1}
C {bus_tap.sym} 1160 -2200 1 0 {name=l5 lab=1}
C {bus_tap.sym} 1430 -2250 1 0 {name=l6 lab=2}
C {bus_tap.sym} 1450 -2200 1 0 {name=l7 lab=2}
C {bus_tap.sym} 1720 -2250 1 0 {name=l8 lab=3}
C {bus_tap.sym} 1740 -2200 1 0 {name=l9 lab=3}
C {bus_tap.sym} 2300 -2250 1 0 {name=l11 lab=5}
C {bus_tap.sym} 2320 -2200 1 0 {name=l12 lab=5}
C {bus_tap.sym} 2590 -2250 1 0 {name=l13 lab=6}
C {bus_tap.sym} 2610 -2200 1 0 {name=l14 lab=6}
C {bus_tap.sym} 2880 -2250 1 0 {name=l15 lab=7}
C {bus_tap.sym} 2900 -2200 1 0 {name=l16 lab=7}
C {bus_tap.sym} 2010 -2250 1 0 {name=l17 lab=4}
C {bus_tap.sym} 2030 -2200 1 0 {name=l18 lab=4}
C {code_shown.sym} -1440 -1590 0 1 {name=s4 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {lab_pin.sym} 200 -1670 0 1 {name=p8 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 200 -1590 3 1 {name=l21 lab=4}
C {bus_tap.sym} 200 -1570 3 1 {name=l22 lab=3}
C {bus_tap.sym} 200 -1550 3 1 {name=l23 lab=2}
C {bus_tap.sym} 200 -1510 3 1 {name=l24 lab=0}
C {bus_tap.sym} 200 -1530 3 1 {name=l25 lab=1}
C {bus_tap.sym} 200 -1610 3 1 {name=l19 lab=5}
C {bus_tap.sym} 200 -1630 3 1 {name=l20 lab=6}
C {bus_tap.sym} 200 -1650 3 1 {name=l26 lab=7}
C {lab_pin.sym} 940 -1750 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1810 0 1 {name=x9}
C {lab_pin.sym} 940 -1770 0 0 {name=p10 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1750 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1810 0 1 {name=x10}
C {lab_pin.sym} 1230 -1770 0 0 {name=p13 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1750 0 0 {name=p19 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1810 0 1 {name=x11}
C {lab_pin.sym} 1520 -1770 0 0 {name=p20 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1750 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1810 0 1 {name=x12}
C {lab_pin.sym} 1810 -1770 0 0 {name=p23 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1750 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1810 0 1 {name=x13}
C {lab_pin.sym} 2100 -1770 0 0 {name=p27 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1750 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1810 0 1 {name=x14}
C {lab_pin.sym} 2390 -1770 0 0 {name=p35 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1750 0 0 {name=p38 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1810 0 1 {name=x15}
C {lab_pin.sym} 2680 -1770 0 0 {name=p45 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1750 0 0 {name=p54 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1810 0 1 {name=x16}
C {lab_pin.sym} 2970 -1770 0 0 {name=p55 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -1870 0 0 {name=p62 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1870 0 0 {name=p63 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1870 0 0 {name=p64 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1870 0 0 {name=p65 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1870 0 0 {name=p66 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1870 0 0 {name=p67 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1870 0 0 {name=p68 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1870 0 0 {name=p98 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1850 0 0 {name=p107 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1230 -1850 0 0 {name=p108 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1520 -1850 0 0 {name=p113 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1810 -1850 0 0 {name=p114 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2100 -1850 0 0 {name=p115 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2390 -1850 0 0 {name=p116 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2680 -1850 0 0 {name=p117 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2970 -1850 0 0 {name=p118 sig_type=std_logic lab=WL1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1230 -3090 0 0 {name=C1 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1230 -3290 2 0 {name=l27 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1210 -3240 2 1 {name=M1
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1230 -3060 0 1 {name=l28 lab=GND}
C {lab_pin.sym} 1170 -3240 0 0 {name=p99 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1520 -3090 0 0 {name=C3 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1520 -3290 2 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1500 -3240 2 1 {name=M3
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1520 -3060 0 1 {name=l30 lab=GND}
C {lab_pin.sym} 1460 -3240 0 0 {name=p119 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1810 -3090 0 0 {name=C4 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1810 -3290 2 0 {name=l31 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -3240 2 1 {name=M4
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1810 -3060 0 1 {name=l32 lab=GND}
C {lab_pin.sym} 1750 -3240 0 0 {name=p121 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2100 -3090 0 0 {name=C5 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2100 -3290 2 0 {name=l33 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2080 -3240 2 1 {name=M5
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2100 -3060 0 1 {name=l34 lab=GND}
C {lab_pin.sym} 2040 -3240 0 0 {name=p123 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -3090 0 0 {name=C6 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2390 -3290 2 0 {name=l35 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -3240 2 1 {name=M6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2390 -3060 0 1 {name=l36 lab=GND}
C {lab_pin.sym} 2330 -3240 0 0 {name=p125 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2680 -3090 0 0 {name=C7 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2680 -3290 2 0 {name=l37 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2660 -3240 2 1 {name=M7
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2680 -3060 0 1 {name=l38 lab=GND}
C {lab_pin.sym} 2620 -3240 0 0 {name=p127 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 -3090 0 0 {name=C8 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2970 -3290 2 0 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2950 -3240 2 1 {name=M8
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2970 -3060 0 1 {name=l40 lab=GND}
C {lab_pin.sym} 2910 -3240 0 0 {name=p129 sig_type=std_logic lab=PRE}
C {iopin.sym} 110 -2100 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 110 -2100 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 110 -2080 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 110 -2080 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 110 -2130 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 110 -2130 0 0 {name=p136 lab=EN_bar}
C {lab_pin.sym} 110 -1810 0 0 {name=p145 sig_type=std_logic lab=TR[0..7]}
C {iopin.sym} 110 -1810 0 0 {name=p146 lab=TR[0..7]}
C {lab_pin.sym} 2970 -1790 0 0 {name=p11 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -1790 0 0 {name=p14 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -1790 0 0 {name=p21 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -1790 0 0 {name=p24 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 1810 -1790 0 0 {name=p29 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -1790 0 0 {name=p37 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -1790 0 0 {name=p46 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -1790 0 0 {name=p50 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 3020 -3150 0 1 {name=p61 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2730 -3150 0 1 {name=p94 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2440 -3150 0 1 {name=p102 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2150 -3150 0 1 {name=p120 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 1860 -3150 0 1 {name=p122 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1570 -3150 0 1 {name=p124 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1280 -3150 0 1 {name=p126 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 990 -3150 0 1 {name=p128 sig_type=std_logic lab=RBL0}
C {voltage_comp/MAC_decoder_old.sym} 840 -2890 0 0 {name=x18}
C {lab_pin.sym} 880 -4610 0 1 {name=p138 lab=MAC_EN}
C {lab_pin.sym} 990 -2950 0 1 {name=p139 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 990 -2970 0 1 {name=p140 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 990 -2930 0 1 {name=p141 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 990 -2910 0 1 {name=p142 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 990 -2850 0 1 {name=p143 sig_type=std_logic lab=MAC[8..0]C0}
C {lab_pin.sym} 990 -2870 0 1 {name=p144 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 1130 -2890 0 0 {name=x17}
C {lab_pin.sym} 1170 -4610 0 1 {name=p149 lab=MAC_EN}
C {lab_pin.sym} 1280 -2950 0 1 {name=p150 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1280 -2970 0 1 {name=p151 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1280 -2930 0 1 {name=p152 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1280 -2910 0 1 {name=p153 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1280 -2850 0 1 {name=p154 sig_type=std_logic lab=MAC[8..0]C1}
C {lab_pin.sym} 1280 -2870 0 1 {name=p155 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 1420 -2890 0 0 {name=x19}
C {lab_pin.sym} 1460 -4610 0 1 {name=p158 lab=MAC_EN}
C {lab_pin.sym} 1570 -2950 0 1 {name=p159 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1570 -2970 0 1 {name=p160 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1570 -2930 0 1 {name=p161 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1570 -2910 0 1 {name=p162 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1570 -2850 0 1 {name=p163 sig_type=std_logic lab=MAC[8..0]C2}
C {lab_pin.sym} 1570 -2870 0 1 {name=p164 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 1710 -2890 0 0 {name=x20}
C {lab_pin.sym} 1750 -4610 0 1 {name=p167 lab=MAC_EN}
C {lab_pin.sym} 1860 -2950 0 1 {name=p168 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1860 -2970 0 1 {name=p169 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1860 -2930 0 1 {name=p170 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1860 -2910 0 1 {name=p171 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1860 -2850 0 1 {name=p172 sig_type=std_logic lab=MAC[8..0]C3}
C {lab_pin.sym} 1860 -2870 0 1 {name=p173 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 2000 -2890 0 0 {name=x21}
C {lab_pin.sym} 2040 -4610 0 1 {name=p176 lab=MAC_EN}
C {lab_pin.sym} 2150 -2950 0 1 {name=p177 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2150 -2970 0 1 {name=p178 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2150 -2930 0 1 {name=p179 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2150 -2910 0 1 {name=p180 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2150 -2850 0 1 {name=p181 sig_type=std_logic lab=MAC[8..0]C4}
C {lab_pin.sym} 2150 -2870 0 1 {name=p182 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 2290 -2890 0 0 {name=x22}
C {lab_pin.sym} 2330 -4610 0 1 {name=p185 lab=MAC_EN}
C {lab_pin.sym} 2440 -2950 0 1 {name=p186 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2440 -2970 0 1 {name=p187 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2440 -2930 0 1 {name=p188 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2440 -2910 0 1 {name=p189 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2440 -2850 0 1 {name=p190 sig_type=std_logic lab=MAC[8..0]C5}
C {lab_pin.sym} 2440 -2870 0 1 {name=p191 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 2580 -2890 0 0 {name=x23}
C {lab_pin.sym} 2620 -4610 0 1 {name=p194 lab=MAC_EN}
C {lab_pin.sym} 2730 -2950 0 1 {name=p195 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2730 -2970 0 1 {name=p196 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2730 -2930 0 1 {name=p197 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2730 -2910 0 1 {name=p198 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2730 -2850 0 1 {name=p199 sig_type=std_logic lab=MAC[8..0]C6}
C {lab_pin.sym} 2730 -2870 0 1 {name=p200 sig_type=std_logic lab=TR[8..0]}
C {voltage_comp/MAC_decoder_old.sym} 2870 -2890 0 0 {name=x24}
C {lab_pin.sym} 2910 -4610 0 1 {name=p203 lab=MAC_EN}
C {lab_pin.sym} 3020 -2950 0 1 {name=p204 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3020 -2970 0 1 {name=p205 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 3020 -2930 0 1 {name=p206 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 3020 -2910 0 1 {name=p207 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 3020 -2850 0 1 {name=p208 sig_type=std_logic lab=MAC[8..0]C7}
C {lab_pin.sym} 3020 -2870 0 1 {name=p209 sig_type=std_logic lab=TR[8..0]}
C {lab_pin.sym} 3020 -2890 0 1 {name=p130 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2730 -2890 0 1 {name=p147 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2440 -2890 0 1 {name=p156 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2150 -2890 0 1 {name=p165 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 1860 -2890 0 1 {name=p174 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1570 -2890 0 1 {name=p183 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1280 -2890 0 1 {name=p192 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 990 -2890 0 1 {name=p201 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 110 -1790 0 0 {name=p210 sig_type=std_logic lab=MAC[0..7]}
C {iopin.sym} 110 -1790 0 0 {name=p211 lab=MAC[0..7]}
C {iopin.sym} 110 -1770 0 0 {name=p212 lab=MACRBL}
C {lab_pin.sym} 110 -1770 0 0 {name=p213 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 940 -1140 0 0 {name=p214 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1200 0 1 {name=x25}
C {lab_pin.sym} 940 -1160 0 0 {name=p215 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1230 -1140 0 0 {name=p216 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1200 0 1 {name=x26}
C {lab_pin.sym} 1230 -1160 0 0 {name=p217 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1520 -1140 0 0 {name=p218 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1200 0 1 {name=x27}
C {lab_pin.sym} 1520 -1160 0 0 {name=p219 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1810 -1140 0 0 {name=p220 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1200 0 1 {name=x28}
C {lab_pin.sym} 1810 -1160 0 0 {name=p221 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2100 -1140 0 0 {name=p222 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1200 0 1 {name=x29}
C {lab_pin.sym} 2100 -1160 0 0 {name=p223 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2390 -1140 0 0 {name=p224 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1200 0 1 {name=x30}
C {lab_pin.sym} 2390 -1160 0 0 {name=p225 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2680 -1140 0 0 {name=p226 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1200 0 1 {name=x31}
C {lab_pin.sym} 2680 -1160 0 0 {name=p227 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2970 -1140 0 0 {name=p228 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1200 0 1 {name=x32}
C {lab_pin.sym} 2970 -1160 0 0 {name=p229 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 940 -1260 0 0 {name=p230 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1260 0 0 {name=p231 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1260 0 0 {name=p232 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1260 0 0 {name=p233 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1260 0 0 {name=p234 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1260 0 0 {name=p235 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1260 0 0 {name=p236 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1260 0 0 {name=p237 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1240 0 0 {name=p238 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1230 -1240 0 0 {name=p239 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1520 -1240 0 0 {name=p240 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1810 -1240 0 0 {name=p241 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2100 -1240 0 0 {name=p242 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2390 -1240 0 0 {name=p243 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2680 -1240 0 0 {name=p244 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2970 -1240 0 0 {name=p245 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2970 -1180 0 0 {name=p246 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2680 -1180 0 0 {name=p247 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2390 -1180 0 0 {name=p248 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2100 -1180 0 0 {name=p249 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1810 -1180 0 0 {name=p250 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1520 -1180 0 0 {name=p251 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1230 -1180 0 0 {name=p252 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 940 -1180 0 0 {name=p253 sig_type=std_logic lab=MACRBL}
C {iopin.sym} 110 -1750 0 0 {name=p254 lab=MACRWL}
C {lab_pin.sym} 110 -1750 0 0 {name=p255 sig_type=std_logic lab=MACRWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3530 -1390 0 0 {name=C9 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 3530 -1590 2 0 {name=l41 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3510 -1540 2 1 {name=M9
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 3530 -1360 0 1 {name=l42 lab=GND}
C {lab_pin.sym} 3470 -1540 0 0 {name=p256 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 3580 -1450 0 1 {name=p257 sig_type=std_logic lab=MACRBL}
C {voltage_comp/MAC_decoder_old.sym} 3430 -1190 0 0 {name=x33}
C {lab_pin.sym} 3580 -1130 0 1 {name=p258 sig_type=std_logic lab=MAC_EN}
C {lab_pin.sym} 3580 -1110 0 1 {name=p259 lab=MAC_EN_bar}
C {lab_pin.sym} 3580 -1250 0 1 {name=p260 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3580 -1270 0 1 {name=p261 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 3580 -1230 0 1 {name=p262 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 3580 -1210 0 1 {name=p263 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 3580 -1150 0 1 {name=p264 sig_type=std_logic lab=HAM[8..0]}
C {lab_pin.sym} 3580 -1170 0 1 {name=p265 sig_type=std_logic lab=TR[8..0]}
C {lab_pin.sym} 3580 -1190 0 1 {name=p266 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2970 -4870 0 0 {name=p267 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 2680 -4870 0 0 {name=p268 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 2390 -4870 0 0 {name=p269 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 2100 -4870 0 0 {name=p270 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 1810 -4870 0 0 {name=p271 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 1520 -4870 0 0 {name=p272 sig_type=std_logic lab=MAC1C0}
C {lab_pin.sym} 1230 -4870 0 0 {name=p273 sig_type=std_logic lab=MAC1C1}
C {lab_pin.sym} 940 -4870 0 0 {name=p274 sig_type=std_logic lab=MAC1C0}
C {bus_tap.sym} 940 -4830 1 0 {name=l43 lab=0}
C {bus_tap.sym} 1230 -4830 1 0 {name=l44 lab=0}
C {bus_tap.sym} 1520 -4830 1 0 {name=l45 lab=0}
C {bus_tap.sym} 1810 -4830 1 0 {name=l46 lab=0}
C {bus_tap.sym} 2100 -4830 1 0 {name=l47 lab=0}
C {bus_tap.sym} 2390 -4830 1 0 {name=l48 lab=0}
C {bus_tap.sym} 2680 -4830 1 0 {name=l49 lab=0}
C {bus_tap.sym} 2970 -4830 1 0 {name=l50 lab=0}
C {lab_pin.sym} 900 -4830 0 0 {name=p275 sig_type=std_logic lab=ABC[0..7]_bar}
C {bus_tap.sym} 870 -1480 1 0 {name=l51 lab=0}
C {bus_tap.sym} 1160 -1480 1 0 {name=l52 lab=1}
C {bus_tap.sym} 1450 -1480 1 0 {name=l53 lab=2}
C {bus_tap.sym} 1740 -1480 1 0 {name=l54 lab=3}
C {bus_tap.sym} 2030 -1480 1 0 {name=l55 lab=4}
C {bus_tap.sym} 2320 -1480 1 0 {name=l56 lab=5}
C {bus_tap.sym} 2610 -1480 1 0 {name=l57 lab=6}
C {bus_tap.sym} 2900 -1480 1 0 {name=l58 lab=7}
C {lab_pin.sym} 830 -1480 0 0 {name=p276 sig_type=std_logic lab=MAC1C[0..7]}
C {bus_tap.sym} 850 -1320 1 0 {name=l59 lab=0}
C {bus_tap.sym} 1140 -1320 1 0 {name=l60 lab=1}
C {bus_tap.sym} 1430 -1320 1 0 {name=l61 lab=2}
C {bus_tap.sym} 1720 -1320 1 0 {name=l62 lab=3}
C {bus_tap.sym} 2010 -1320 1 0 {name=l63 lab=4}
C {bus_tap.sym} 2300 -1320 1 0 {name=l64 lab=5}
C {bus_tap.sym} 2590 -1320 1 0 {name=l65 lab=6}
C {bus_tap.sym} 2880 -1320 1 0 {name=l66 lab=7}
C {lab_pin.sym} 600 -1320 0 0 {name=p277 sig_type=std_logic lab=MAC1C[0..7]}
C {inv.sym} 660 -1320 0 0 {name=x34[0..7]}
C {lab_pin.sym} 660 -1340 0 1 {name=p278 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 660 -1300 0 1 {name=p279 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 810 -1220 0 0 {name=p280 sig_type=std_logic lab=MAC2_barC[0..7]}
C {code_shown.sym} -2470 -1590 0 1 {name=s1 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {iopin.sym} 110 -2200 0 0 {name=p281 lab=MAC_EN}
C {lab_pin.sym} 110 -2200 0 0 {name=p282 sig_type=std_logic lab=MAC_EN}
C {iopin.sym} 110 -2180 0 0 {name=p283 lab=MAC_EN_bar}
C {lab_pin.sym} 110 -2180 0 0 {name=p284 lab=MAC_EN_bar}
C {lab_pin.sym} 990 -2810 0 1 {name=p285 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 990 -2830 0 1 {name=p286 lab=MAC_EN}
C {lab_pin.sym} 1280 -2810 0 1 {name=p287 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1280 -2830 0 1 {name=p288 lab=MAC_EN}
C {lab_pin.sym} 1570 -2810 0 1 {name=p289 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1570 -2830 0 1 {name=p290 lab=MAC_EN}
C {lab_pin.sym} 1860 -2810 0 1 {name=p291 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1860 -2830 0 1 {name=p292 lab=MAC_EN}
C {lab_pin.sym} 2150 -2810 0 1 {name=p293 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2150 -2830 0 1 {name=p294 lab=MAC_EN}
C {lab_pin.sym} 2440 -2810 0 1 {name=p295 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2440 -2830 0 1 {name=p296 lab=MAC_EN}
C {lab_pin.sym} 2730 -2810 0 1 {name=p297 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2730 -2830 0 1 {name=p298 lab=MAC_EN}
C {lab_pin.sym} 3020 -2810 0 1 {name=p299 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 3020 -2830 0 1 {name=p300 lab=MAC_EN}
C {code_shown.sym} -1200 -1750 0 0 {name=s5 only_toplevel=false value=
"
.param VSS=0 VCC=1.8 BL_period=10ns t_dly=1ns rise=10ps fall =10ps rwl_time=0.5ns pre_time=6ns clk_period=30ns

.include "/home/user/pyvenvs/sky130venv/ham_code.spice"
.include "/home/user/pyvenvs/sky130venv/thresholds.spice

.save all
"}
