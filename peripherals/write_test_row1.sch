v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -1760 -2930 -960 -2530 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.4124
ypos2=1.5146
divy=5
subdivy=1
unity=1
x1=1.5736705e-07
x2=1.5793901e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row1.raw
autoload=0
digital=1
color="4 5 6 7 8 9"
node="s2
s1
s0
en
pre
rwl"
hilight_wave=-1}
B 2 -1760 -2440 -960 -2040 {flags=graph
y1=-0.027
y2=1.9
ypos1=1.61095
ypos2=3.53795
divy=5
subdivy=1
unity=1
x1=1.5736705e-07
x2=1.5793901e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row1.raw
autoload=0
digital=1
color="8 5 6 7 8 9 10 11 6 8 8 8 8 8 8 8 8"
node="en
bl7
bl6
bl5
bl4
bl3
bl2
bl1
bl0
blb7
blb6
blb5
blb4
blb3
blb2
blb1
blb0"
hilight_wave=0}
B 2 -940 -2440 -140 -2040 {flags=graph
y1=-0.035
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x2=1.5793901e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row1.raw
autoload=0
digital=0
hilight_wave=2
color="4 5 6"
node="pre
rwl
rbl7"
x1=1.5736705e-07}
B 2 -942.283778888446 -2930 -142.2837788884458 -2530 {flags=graph
y1=-0.027
y2=1.9
ypos1=0.1657
ypos2=2.0927
divy=5
subdivy=1
unity=1
x1=1.5736705e-07
x2=1.5793901e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/write_test_row1.raw
autoload=0
digital=1
hilight_wave=-1
color="19 5 6 7 8 9 10 11 12"
node="data;x1.q,x2.q,x3.q,x4.q,x5.q,x6.q,x7.q,x8.q

x8.q
x7.q
x6.q
x5.q
x4.q
x3.q
x2.q
x1.q"}
N 370 -1440 370 -1350 {lab=RBL7}
N 370 -1380 440 -1380 {lab=RBL7}
N 370 -1520 370 -1500 {lab=GND}
N 370 -1470 380 -1470 {lab=GND}
N 380 -1510 380 -1470 {lab=GND}
N 370 -1510 380 -1510 {lab=GND}
N 310 -1470 330 -1470 {lab=PRE}
N 280 -2250 2550 -2250 {lab=BL[0..7]
bus=true}
N 280 -2200 2550 -2200 {lab=BLB[0..7]
bus=true}
N 310 -2190 310 -2080 {lab=BLB0}
N 310 -2080 370 -2080 {lab=BLB0}
N 290 -2240 290 -2060 {lab=BL0
bus}
N 290 -2060 370 -2060 {lab=BL0}
N 600 -2190 600 -2080 {lab=BLB1}
N 600 -2080 660 -2080 {lab=BLB1}
N 580 -2240 580 -2060 {lab=BL1}
N 580 -2060 660 -2060 {lab=BL1}
N 890 -2190 890 -2080 {lab=BLB2}
N 890 -2080 950 -2080 {lab=BLB2}
N 870 -2240 870 -2060 {lab=BL2}
N 870 -2060 950 -2060 {lab=BL2}
N 1180 -2190 1180 -2080 {lab=BLB3}
N 1180 -2080 1240 -2080 {lab=BLB3}
N 1160 -2240 1160 -2060 {lab=BL3}
N 1160 -2060 1240 -2060 {lab=BL3}
N 1470 -2190 1470 -2080 {lab=BLB4}
N 1470 -2080 1530 -2080 {lab=BLB4}
N 1450 -2240 1450 -2060 {lab=BL4}
N 1450 -2060 1530 -2060 {lab=BL4}
N 1760 -2190 1760 -2080 {lab=BLB5}
N 1760 -2080 1820 -2080 {lab=BLB5}
N 1740 -2240 1740 -2060 {lab=BL5}
N 1740 -2060 1820 -2060 {lab=BL5}
N 2050 -2190 2050 -2080 {lab=BLB6}
N 2050 -2080 2110 -2080 {lab=BLB6}
N 2030 -2240 2030 -2060 {lab=BL6}
N 2030 -2060 2110 -2060 {lab=BL6}
N 2340 -2190 2340 -2080 {lab=BLB7}
N 2340 -2080 2400 -2080 {lab=BLB7}
N 2320 -2240 2320 -2060 {lab=BL7}
N 2320 -2060 2400 -2060 {lab=BL7}
N 200 -1670 200 -1480 {lab=WL[0..7]
bus=true}
N 150 -1640 190 -1640 {lab=WL7}
N 150 -1620 190 -1620 {lab=WL6}
N 150 -1600 190 -1600 {lab=WL5}
N 150 -1580 190 -1580 {lab=WL4}
N 150 -1560 190 -1560 {lab=WL3}
N 150 -1540 190 -1540 {lab=WL2}
N 150 -1520 190 -1520 {lab=WL1}
N 150 -1500 190 -1500 {lab=WL0}
C {iopin.sym} 110 -2040 0 0 {name=p7 lab=WL[0..7]}
C {lab_pin.sym} 110 -2040 0 0 {name=p18 sig_type=std_logic lab=WL[0..7]}
C {lab_pin.sym} 370 -2100 0 0 {name=p1 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 370 -2000 0 0 {name=p43 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 370 -2120 0 0 {name=p51 sig_type=std_logic lab=VCC}
C {code.sym} -1330 -1760 0 0 {
name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
spice_ignore=false
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
"
spice_ignore=false
      }
C {code_shown.sym} -960 -1760 0 1 {name=s2 only_toplevel=false spice_ignore=false value=
"
.param VCC=1.8 VSS=0

V_VCC VCC 0 DC 1.8
V_VSS VSS 0 DC 0
"}
C {iopin.sym} 110 -1950 0 0 {name=p69 lab=S2}
C {iopin.sym} 110 -1930 0 0 {name=p70 lab=S1}
C {iopin.sym} 110 -1910 0 0 {name=p71 lab=S0}
C {lab_pin.sym} 110 -1950 0 0 {name=p72 sig_type=std_logic lab=S2}
C {lab_pin.sym} 110 -1930 0 0 {name=p73 sig_type=std_logic lab=S1}
C {lab_pin.sym} 110 -1910 0 0 {name=p74 sig_type=std_logic lab=S0}
C {iopin.sym} 110 -2200 0 0 {name=p78 lab=VCC}
C {iopin.sym} 110 -2180 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 110 -2180 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 110 -2200 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -2150 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 110 -2150 0 0 {name=p83 sig_type=std_logic lab=EN}
C {code_shown.sym} -500 -1580 0 1 {name=s3 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=8 pre_time=6ns read_time=2ns write_delay=10ns 


*V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
V_BLB0 BL0 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL1 BLB1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
V_BLB1 BL1 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})

V_BL2 BLB2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})
V_BLB2 BL2 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_BL3 BLB3 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})
V_BLB3 BL3 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})

V_BL4 BLB4 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})
V_BLB4 BL4 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})

V_BL5 BLB5 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})
V_BLB5 BL5 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})

V_BL6 BLB6 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})
V_BLB6 BL6 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})

V_BL7 BLB7 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})
V_BLB7 BL7 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds*2\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds*2\})

.tran 0.01ns \{BL_period*2*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {launcher.sym} -980 -2480 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/write_test_row1.raw tran"
}
C {8T_sram_cell_c.sym} 2550 -2060 0 1 {name=x8}
C {lab_pin.sym} 370 -2020 0 0 {name=p87 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 370 -2040 0 0 {name=p103 sig_type=std_logic lab=RBL7}
C {iopin.sym} 110 -1880 0 0 {name=p89 lab=RBL[0..7]}
C {iopin.sym} 110 -1860 0 0 {name=p90 lab=RWL}
C {lab_pin.sym} 110 -1880 0 0 {name=p91 sig_type=std_logic lab=RBL[0..7]}
C {lab_pin.sym} 110 -1860 0 0 {name=p92 sig_type=std_logic lab=RWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 -1320 0 0 {name=C2 model=cap_mim_m3_1 W=25 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 370 -1520 2 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 350 -1470 2 1 {name=M2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 370 -1290 0 1 {name=l10 lab=GND}
C {iopin.sym} 110 -1840 0 0 {name=p93 lab=PRE}
C {lab_pin.sym} 110 -1840 0 0 {name=p95 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 310 -1470 0 0 {name=p96 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 660 -2100 0 0 {name=p2 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 660 -2000 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 660 -2120 0 0 {name=p6 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 520 -2060 0 1 {name=x1}
C {lab_pin.sym} 660 -2020 0 0 {name=p15 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 660 -2040 0 0 {name=p16 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 950 -2100 0 0 {name=p28 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 950 -2000 0 0 {name=p31 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 950 -2120 0 0 {name=p32 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 810 -2060 0 1 {name=x2}
C {lab_pin.sym} 950 -2020 0 0 {name=p33 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 950 -2040 0 0 {name=p34 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 1240 -2100 0 0 {name=p36 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1240 -2000 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1240 -2120 0 0 {name=p40 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1100 -2060 0 1 {name=x3}
C {lab_pin.sym} 1240 -2020 0 0 {name=p41 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1240 -2040 0 0 {name=p42 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 1530 -2100 0 0 {name=p44 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1530 -2000 0 0 {name=p47 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1530 -2120 0 0 {name=p48 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1390 -2060 0 1 {name=x4}
C {lab_pin.sym} 1530 -2020 0 0 {name=p49 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1530 -2040 0 0 {name=p52 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 1820 -2100 0 0 {name=p53 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1820 -2000 0 0 {name=p56 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1820 -2120 0 0 {name=p57 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1680 -2060 0 1 {name=x5}
C {lab_pin.sym} 1820 -2020 0 0 {name=p58 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1820 -2040 0 0 {name=p88 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2110 -2100 0 0 {name=p97 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2110 -2000 0 0 {name=p100 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2110 -2120 0 0 {name=p101 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1970 -2060 0 1 {name=x6}
C {lab_pin.sym} 2110 -2020 0 0 {name=p104 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2110 -2040 0 0 {name=p105 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2400 -2100 0 0 {name=p106 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2400 -2000 0 0 {name=p109 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2400 -2120 0 0 {name=p110 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2260 -2060 0 1 {name=x7}
C {lab_pin.sym} 2400 -2020 0 0 {name=p111 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2400 -2040 0 0 {name=p112 sig_type=std_logic lab=RBL7}
C {iopin.sym} 110 -2010 0 0 {name=p17 lab=BL[0..7]}
C {lab_pin.sym} 110 -2010 0 0 {name=p26 sig_type=std_logic lab=BL[0..7]}
C {iopin.sym} 110 -1990 0 0 {name=p59 lab=BLB[0..7]}
C {lab_pin.sym} 110 -1990 0 0 {name=p60 sig_type=std_logic lab=BLB[0..7]}
C {logic gates/decoder.sym} 100 -1570 0 0 {name=x77}
C {lab_pin.sym} 40 -1590 0 0 {name=p75 sig_type=std_logic lab=S2}
C {lab_pin.sym} 40 -1570 0 0 {name=p76 sig_type=std_logic lab=S1}
C {lab_pin.sym} 40 -1550 0 0 {name=p77 sig_type=std_logic lab=S0}
C {lab_pin.sym} 40 -1520 0 0 {name=p84 sig_type=std_logic lab=EN}
C {lab_pin.sym} 100 -1660 0 0 {name=p85 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -1480 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {bus_tap.sym} 280 -2250 1 0 {name=l2 lab=0}
C {lab_pin.sym} 280 -2250 0 0 {name=p3 sig_type=std_logic lab=BL[0..7]}
C {lab_pin.sym} 280 -2200 0 0 {name=p4 sig_type=std_logic lab=BLB[0..7]}
C {bus_tap.sym} 300 -2200 1 0 {name=l3 lab=0}
C {bus_tap.sym} 570 -2250 1 0 {name=l4 lab=1}
C {bus_tap.sym} 590 -2200 1 0 {name=l5 lab=1}
C {bus_tap.sym} 860 -2250 1 0 {name=l6 lab=2}
C {bus_tap.sym} 880 -2200 1 0 {name=l7 lab=2}
C {bus_tap.sym} 1150 -2250 1 0 {name=l8 lab=3}
C {bus_tap.sym} 1170 -2200 1 0 {name=l9 lab=3}
C {bus_tap.sym} 1730 -2250 1 0 {name=l11 lab=5}
C {bus_tap.sym} 1750 -2200 1 0 {name=l12 lab=5}
C {bus_tap.sym} 2020 -2250 1 0 {name=l13 lab=6}
C {bus_tap.sym} 2040 -2200 1 0 {name=l14 lab=6}
C {bus_tap.sym} 2310 -2250 1 0 {name=l15 lab=7}
C {bus_tap.sym} 2330 -2200 1 0 {name=l16 lab=7}
C {bus_tap.sym} 1440 -2250 1 0 {name=l17 lab=4}
C {bus_tap.sym} 1460 -2200 1 0 {name=l18 lab=4}
C {code_shown.sym} -1440 -1590 0 1 {name=s4 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {lab_pin.sym} 200 -1670 0 1 {name=p8 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 200 -1590 3 1 {name=l21 lab=4}
C {bus_tap.sym} 200 -1570 3 1 {name=l22 lab=3}
C {bus_tap.sym} 200 -1550 3 1 {name=l23 lab=2}
C {bus_tap.sym} 200 -1510 3 1 {name=l24 lab=0}
C {bus_tap.sym} 200 -1530 3 1 {name=l25 lab=1}
C {bus_tap.sym} 200 -1610 3 1 {name=l19 lab=5}
C {bus_tap.sym} 200 -1630 3 1 {name=l20 lab=6}
C {bus_tap.sym} 200 -1650 3 1 {name=l26 lab=7}
C {lab_pin.sym} 440 -1380 0 1 {name=p50 sig_type=std_logic lab=RBL7}
C {iopin.sym} 110 -2100 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 110 -2100 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 110 -2080 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 110 -2080 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 110 -2130 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 110 -2130 0 0 {name=p136 lab=EN_bar}
C {code_shown.sym} -2520 -1560 0 1 {name=s1 only_toplevel=false spice_ignore=false value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=0.5ns write_delay=10ns 


*V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_S0 S0 0 DC 0
V_S1 S1 0 DC 0
V_S2 S2 0 DC 0

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 60ns 0 80ns 0 100ns 0 120ns 0 140ns 0 159.99ns 0 160ns 1.8)
V_BL1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 60ns 0 80ns 0 100ns 0 120ns 0 139.99ns 0 140ns 1.8 160ns 1.8)
V_BL2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 60ns 0 80ns 0 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8 160ns 1.8)
V_BL3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 60ns 0 80ns 0 99.99ns 0 100ns 1.8 120ns 1.8 140ns 1.8 160ns 1.8)
V_BL4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 60ns 0 79.99ns 0 80ns 1.8 100ns 1.8 120ns 1.8 140ns 1.8 160ns 1.8)
V_BL5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 100ns 1.8 120ns 1.8 140ns 1.8 160ns 1.8)
V_BL6 BL6 0 PWL(0ns 0 20ns 0 39.99ns 0 40ns 1.8 60ns 1.8 80ns 1.8 100ns 1.8 120ns 1.8 140ns 1.8 160ns 1.8)
V_BL7 BL7 0 PWL(0ns 0 19.99ns 0 20ns 1.8 40ns 1.8 60ns 1.8 80ns 1.8 100ns 1.8 120ns 1.8 140ns 1.8 160ns 1.8)
V_BLB0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 60ns 1.8 80ns 1.8 100ns 1.8 120ns 1.8 140ns 1.8 159.99ns 1.8 160ns 0)
V_BLB1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 60ns 1.8 80ns 1.8 100ns 1.8 120ns 1.8 139.99ns 1.8 140ns 0 160ns 0)
V_BLB2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 60ns 1.8 80ns 1.8 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0 160ns 0)
V_BLB3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 120ns 0 140ns 0 160ns 0)
V_BLB4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 60ns 1.8 79.99ns 1.8 80ns 0 100ns 0 120ns 0 140ns 0 160ns 0)
V_BLB5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 100ns 0 120ns 0 140ns 0 160ns 0)
V_BLB6 BLB6 0 PWL(0ns 1.8 20ns 1.8 39.99ns 1.8 40ns 0 60ns 0 80ns 0 100ns 0 120ns 0 140ns 0 160ns 0)
V_BLB7 BLB7 0 PWL(0ns 1.8 19.99ns 1.8 20ns 0 40ns 0 60ns 0 80ns 0 100ns 0 120ns 0 140ns 0 160ns 0)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds*2\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds*2\})

.tran 0.01ns \{BL_period*9\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
