v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -370 -30 430 370 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.17622128
ypos2=1.6271395
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
legend=1
sim_type=tran
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 20 20 8 6"
node="en
pre
rwl
macrwl
clk
mac_en
mac_en_bar
ROW1;xsram8.q,xsram7.q,xsram6.q,xsram5.q,xsram4.q,xsram3.q,xsram2.q,xsram1.q
ROW2;xsram16.q,xsram15.q,xsram14.q,xsram13.q,xsram12.q,xsram11.q,xsram10.q,xsram9.q
ROW3;xsram24.q,xsram23.q,xsram22.q,xsram21.q,xsram20.q,xsram19.q,xsram18.q,xsram17.q
ROW4;xsram32.q,xsram31.q,xsram30.q,xsram29.q,xsram28.q,xsram27.q,xsram26.q,xsram25.q
ROW5;xsram40.q,xsram39.q,xsram38.q,xsram37.q,xsram36.q,xsram35.q,xsram34.q,xsram33.q
ROW6;xsram48.q,xsram47.q,xsram46.q,xsram45.q,xsram44.q,xsram43.q,xsram42.q,xsram41.q
ROW7;xsram56.q,xsram55.q,xsram54.q,xsram53.q,xsram52.q,xsram51.q,xsram50.q,xsram49.q
ROW8;xsram64.q,xsram63.q,xsram62.q,xsram61.q,xsram60.q,xsram59.q,xsram58.q,xsram57.q
ROW9;xsram_ham8.q,xsram_ham7.q,xsram_ham6.q,xsram_ham5.q,xsram_ham4.q,xsram_ham3.q,xsram_ham2.q,xsram_ham1.q
mac;mac_c7,mac_c6,mac_c5,mac_c4,mac_c3,mac_c2,mac_c1,mac_c0
mac_bar;mac_c_bar7,mac_c_bar6,mac_c_bar5,mac_c_bar4,mac_c_bar3,mac_c_bar2,mac_c_bar1,mac_c_bar0
HAM;mac8,mac7,mac6,mac5,mac4,mac3,mac2,mac1,mac0"
hilight_wave=-1}
B 2 -1760 -4130 -960 -3730 {flags=graph,unlocked
y1=-0.027
y2=1.9
ypos1=0.7438
ypos2=2.6708
divy=5
subdivy=1
unity=1
x1=6.35e-09
x2=1.3335e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
color="4 5 6 7 8 9 10 11 7 7 7 7"
node="bl7
bl6
bl5
bl4
bl3
bl2
bl1
bl0


blb3
blb2
blb1
blb0"
hilight_wave=-1}
B 2 -940 -4540 -140 -4140 {flags=graph
y1=-0.059
y2=1.9
ypos1=0.06935
ypos2=1.99635
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
hilight_wave=7
sim_type=tran
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20"
node="clk
xmac_dec8.net1_1
xmac_dec8.net1_0
xmac_dec7.net1_1
xmac_dec7.net1_0
xmac_dec6.net1_1
xmac_dec6.net1_0
xmac_dec5.net1_1
xmac_dec5.net1_0
xmac_dec4.net1_1
xmac_dec4.net1_0
xmac_dec3.net1_1
xmac_dec3.net1_0
xmac_dec2.net1_1
xmac_dec2.net1_0
xmac_dec1.net1_1
xmac_dec1.net1_0"}
B 2 -2580 -3310 -1780 -2910 {flags=graph
y1=-0.052
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=7
sim_type=tran
color="4 5 6 7 8 9 10 11"
node="mac_c7
mac_c6
mac_c5
mac_c4
mac_c3
mac_c2
mac_c1
mac_c0"}
B 2 -940 -3320 -140 -2920 {flags=graph
y1=-0.31
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=2
sim_type=tran
color="4 5"
node="xmac_dec5.x1.x1.out+
xmac_dec5.x1.x1.out-"}
B 2 -940 -2910 -140 -2510 {flags=graph
y1=1.7605904
y2=1.811128
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=8
sim_type=tran
color="4 5 6 7 8 9 10 11 12 13 13 13 13 13 13 13 13 13"
node="rbl7
rbl6
rbl5
rbl4
rbl3
rbl2
rbl1
rbl0
macrbl
clk

tr7
tr6
tr5
tr4
tr3
tr2
tr1
tr0"}
B 2 -940 -3720 -140 -3320 {flags=graph
y1=-0.31
y2=1.8
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=0
sim_type=tran
color="4 5"
node="xmac_dec5.x1.x2.out+
xmac_dec5.x1.x2.out-"}
B 2 -1760 -3720 -960 -3320 {flags=graph
y1=1.9
y2=3.868
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=1
sim_type=tran
color="4 5"
node="xmac_dec8.net1_1
xmac_dec8.net2_1"}
B 2 -1760 -3320 -960 -2920 {flags=graph
y1=-0.068
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=1
sim_type=tran
color="4 5"
node="xmac_dec8.net1_0
xmac_dec8.net2_0"}
B 2 -1750 -2910 -950 -2510 {flags=graph
y1=0.095934363
y2=2.8222005
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
hilight_wave=0
sim_type=tran
color="4 5 6 7 8 9 10 11"
node="S;s2,s1,s0
en
pre
rwl
clk
mac_en
macrwl
wl8"
rainbow=1}
B 2 -2580 -4130 -1780 -3730 {flags=graph
y1=-0.052
y2=1.9
ypos1=0.3584
ypos2=2.2854
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
hilight_wave=7
sim_type=tran
color="4 5 6 7 8 9 10 11 6"
node="mac_c7
mac_c6
mac_c5
mac_c4
mac_c3
mac_c2
mac_c1
mac_c0
wl8"}
B 2 -2580 -3720 -1780 -3320 {flags=graph
y1=-0.052
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
hilight_wave=7
sim_type=tran
color="4 5 6 7 8 9 10 11"
node="mac_c_bar7
mac_c_bar6
mac_c_bar5
mac_c_bar4
mac_c_bar3
mac_c_bar2
mac_c_bar1
mac_c_bar0"}
B 2 -2580 -2910 -1780 -2510 {flags=graph
y1=0
y2=0.01
ypos1=-0.50875
ypos2=1.41825
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=0
hilight_wave=7
sim_type=tran
color=20
node="hi;mac8,xham_dec.d7,xham_dec.d6,xham_dec.d5,xham_dec.d4,xham_dec.d3,xham_dec.d2,xham_dec.d1,vcc"}
B 2 -370 -450 430 -50 {flags=graph
y1=0.095934363
y2=2.8222005
ypos1=0.037063071
ypos2=2.8640387
divy=5
subdivy=1
unity=1
x1=6.65e-09
x2=1.3965e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_PART1&2_b.raw
autoload=0
digital=1
hilight_wave=0
sim_type=tran
rainbow=1
color="20 20 20 20 20 20 20 20 20"
node="mac8
xham_dec.d7
xham_dec.d6
xham_dec.d5
xham_dec.d4
xham_dec.d3
xham_dec.d2
xham_dec.d1
vcc"}
B 4 770 -3310 3160 -200 {fill=false}
N 200 -1670 200 -1480 {lab=WL[0..7]
bus=true}
N 150 -1640 190 -1640 {lab=WL7}
N 150 -1620 190 -1620 {lab=WL6}
N 150 -1600 190 -1600 {lab=WL5}
N 150 -1580 190 -1580 {lab=WL4}
N 150 -1560 190 -1560 {lab=WL3}
N 150 -1540 190 -1540 {lab=WL2}
N 150 -1520 190 -1520 {lab=WL1}
N 150 -1500 190 -1500 {lab=WL0}
N 140 -920 140 -830 {lab=MACRBL}
N 140 -860 190 -860 {lab=MACRBL}
N 140 -1000 140 -980 {lab=GND}
N 140 -950 150 -950 {lab=GND}
N 150 -990 150 -950 {lab=GND}
N 140 -990 150 -990 {lab=GND}
N 80 -950 100 -950 {lab=PRE}
N 930 -3270 940 -3270 {lab=VSS}
N 930 -3270 930 -3240 {lab=VSS}
N 930 -3240 940 -3240 {lab=VSS}
N 980 -3240 1000 -3240 {lab=PRE}
N 940 -3210 940 -3120 {lab=RBL0}
N 940 -3150 990 -3150 {lab=RBL0}
N 1220 -3270 1230 -3270 {lab=VSS}
N 1220 -3270 1220 -3240 {lab=VSS}
N 1220 -3240 1230 -3240 {lab=VSS}
N 1270 -3240 1290 -3240 {lab=PRE}
N 1230 -3210 1230 -3120 {lab=RBL1}
N 1230 -3150 1280 -3150 {lab=RBL1}
N 1510 -3270 1520 -3270 {lab=VSS}
N 1510 -3270 1510 -3240 {lab=VSS}
N 1510 -3240 1520 -3240 {lab=VSS}
N 1560 -3240 1580 -3240 {lab=PRE}
N 1520 -3210 1520 -3120 {lab=RBL2}
N 1520 -3150 1570 -3150 {lab=RBL2}
N 1800 -3270 1810 -3270 {lab=VSS}
N 1800 -3270 1800 -3240 {lab=VSS}
N 1800 -3240 1810 -3240 {lab=VSS}
N 1850 -3240 1870 -3240 {lab=PRE}
N 1810 -3210 1810 -3120 {lab=RBL3}
N 1810 -3150 1860 -3150 {lab=RBL3}
N 2090 -3270 2100 -3270 {lab=VSS}
N 2090 -3270 2090 -3240 {lab=VSS}
N 2090 -3240 2100 -3240 {lab=VSS}
N 2140 -3240 2160 -3240 {lab=PRE}
N 2100 -3210 2100 -3120 {lab=RBL4}
N 2100 -3150 2150 -3150 {lab=RBL4}
N 2380 -3270 2390 -3270 {lab=VSS}
N 2380 -3270 2380 -3240 {lab=VSS}
N 2380 -3240 2390 -3240 {lab=VSS}
N 2430 -3240 2450 -3240 {lab=PRE}
N 2390 -3210 2390 -3120 {lab=RBL5}
N 2390 -3150 2440 -3150 {lab=RBL5}
N 2670 -3270 2680 -3270 {lab=VSS}
N 2670 -3270 2670 -3240 {lab=VSS}
N 2670 -3240 2680 -3240 {lab=VSS}
N 2720 -3240 2740 -3240 {lab=PRE}
N 2680 -3210 2680 -3120 {lab=RBL6}
N 2680 -3150 2730 -3150 {lab=RBL6}
N 2960 -3270 2970 -3270 {lab=VSS}
N 2960 -3270 2960 -3240 {lab=VSS}
N 2960 -3240 2970 -3240 {lab=VSS}
N 3010 -3240 3030 -3240 {lab=PRE}
N 2970 -3210 2970 -3120 {lab=RBL7}
N 2970 -3150 3020 -3150 {lab=RBL7}
C {iopin.sym} 110 -2040 0 0 {name=p7 lab=WL[0..7]}
C {lab_pin.sym} 110 -2040 0 0 {name=p18 sig_type=std_logic lab=WL[0..7]}
C {code.sym} -1330 -1760 0 0 {
name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
spice_ignore=false
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
"
spice_ignore=false
      }
C {code_shown.sym} -1200 -1890 0 0 {name=s2 only_toplevel=false spice_ignore=false value=
"
.param VCC=1.8 VSS=0

V_VCC VCC 0 DC \{VCC\}
V_VSS VSS 0 DC \{VSS\}
"}
C {iopin.sym} 110 -1950 0 0 {name=p69 lab=S2}
C {iopin.sym} 110 -1930 0 0 {name=p70 lab=S1}
C {iopin.sym} 110 -1910 0 0 {name=p71 lab=S0}
C {lab_pin.sym} 110 -1950 0 0 {name=p72 sig_type=std_logic lab=S2}
C {lab_pin.sym} 110 -1930 0 0 {name=p73 sig_type=std_logic lab=S1}
C {lab_pin.sym} 110 -1910 0 0 {name=p74 sig_type=std_logic lab=S0}
C {iopin.sym} 110 -2310 0 0 {name=p78 lab=VCC}
C {iopin.sym} 110 -2290 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 110 -2290 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 110 -2310 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -2150 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 110 -2150 0 0 {name=p83 sig_type=std_logic lab=EN}
C {code_shown.sym} -480 -1590 0 1 {name=s3 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=8 pre_time=6ns read_time=2ns write_delay=10ns 


*V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
V_BLB0 BL0 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL1 BLB1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
V_BLB1 BL1 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})

V_BL2 BLB2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})
V_BLB2 BL2 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_BL3 BLB3 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})
V_BLB3 BL3 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})

V_BL4 BLB4 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})
V_BLB4 BL4 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})

V_BL5 BLB5 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})
V_BLB5 BL5 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})

V_BL6 BLB6 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})
V_BLB6 BL6 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})

V_BL7 BLB7 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})
V_BLB7 BL7 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds*2\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds*2\})

.tran 0.01ns \{BL_period*2*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {iopin.sym} 110 -1880 0 0 {name=p89 lab=RBL[0..7]}
C {iopin.sym} 110 -1860 0 0 {name=p90 lab=RWL}
C {lab_pin.sym} 110 -1880 0 0 {name=p91 sig_type=std_logic lab=RBL[0..7]}
C {lab_pin.sym} 110 -1860 0 0 {name=p92 sig_type=std_logic lab=RWL}
C {iopin.sym} 110 -1840 0 0 {name=p93 lab=PRE}
C {lab_pin.sym} 110 -1840 0 0 {name=p95 sig_type=std_logic lab=PRE}
C {iopin.sym} 110 -2010 0 0 {name=p17 lab=BL[0..7]}
C {lab_pin.sym} 110 -2010 0 0 {name=p26 sig_type=std_logic lab=BL[0..7]}
C {iopin.sym} 110 -1990 0 0 {name=p59 lab=BLB[0..7]}
C {lab_pin.sym} 110 -1990 0 0 {name=p60 sig_type=std_logic lab=BLB[0..7]}
C {logic gates/decoder.sym} 100 -1570 0 0 {name=x77}
C {lab_pin.sym} 40 -1590 0 0 {name=p75 sig_type=std_logic lab=S2}
C {lab_pin.sym} 40 -1570 0 0 {name=p76 sig_type=std_logic lab=S1}
C {lab_pin.sym} 40 -1550 0 0 {name=p77 sig_type=std_logic lab=S0}
C {lab_pin.sym} 40 -1520 0 0 {name=p84 sig_type=std_logic lab=EN}
C {lab_pin.sym} 100 -1660 0 0 {name=p85 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -1480 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {code_shown.sym} -1440 -1590 0 1 {name=s4 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {lab_pin.sym} 200 -1670 0 1 {name=p8 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 200 -1590 3 1 {name=l21 lab=4}
C {bus_tap.sym} 200 -1570 3 1 {name=l22 lab=3}
C {bus_tap.sym} 200 -1550 3 1 {name=l23 lab=2}
C {bus_tap.sym} 200 -1510 3 1 {name=l24 lab=0}
C {bus_tap.sym} 200 -1530 3 1 {name=l25 lab=1}
C {bus_tap.sym} 200 -1610 3 1 {name=l19 lab=5}
C {bus_tap.sym} 200 -1630 3 1 {name=l20 lab=6}
C {bus_tap.sym} 200 -1650 3 1 {name=l26 lab=7}
C {iopin.sym} 110 -2100 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 110 -2100 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 110 -2080 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 110 -2080 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 110 -2130 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 110 -2130 0 0 {name=p136 lab=EN_bar}
C {lab_pin.sym} 110 -1810 0 0 {name=p145 sig_type=std_logic lab=TR[0..7]}
C {iopin.sym} 110 -1810 0 0 {name=p146 lab=TR[0..7]}
C {lab_pin.sym} 110 -1790 0 0 {name=p210 sig_type=std_logic lab=MAC[0..8]}
C {iopin.sym} 110 -1790 0 0 {name=p211 lab=MAC[0..8]}
C {iopin.sym} 110 -1770 0 0 {name=p212 lab=MACRBL}
C {lab_pin.sym} 110 -1770 0 0 {name=p213 sig_type=std_logic lab=MACRBL}
C {iopin.sym} 110 -1750 0 0 {name=p254 lab=MACRWL}
C {lab_pin.sym} 110 -1750 0 0 {name=p255 sig_type=std_logic lab=MACRWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 140 -800 0 0 {name=C9 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 140 -1000 2 0 {name=l41 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 120 -950 2 1 {name=M9
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 140 -770 0 1 {name=l42 lab=GND}
C {lab_pin.sym} 80 -950 0 0 {name=p256 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 190 -860 0 1 {name=p257 sig_type=std_logic lab=MACRBL}
C {code_shown.sym} -2470 -1590 0 1 {name=s1 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {iopin.sym} 110 -2200 0 0 {name=p281 lab=MAC_EN}
C {lab_pin.sym} 110 -2200 0 0 {name=p282 sig_type=std_logic lab=MAC_EN}
C {iopin.sym} 110 -2180 0 0 {name=p283 lab=MAC_EN_bar}
C {lab_pin.sym} 110 -2180 0 0 {name=p284 lab=MAC_EN_bar}
C {code_shown.sym} -1200 -1750 0 0 {name=s5 only_toplevel=false value=
"
.param VSS=0 VCC=1.8 BL_period=3ns t_dly=1ns rise=10ps fall =10ps rwl_time=3.5ns pre_time=6ns clk_period=30ns

.include "/home/user/pyvenvs/sky130venv/spice_files/ham_code.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/thresholds_b.spice"
.save all

"}
C {code_shown.sym} -980 -1890 0 0 {name=s6 only_toplevel=false spice_ignore=false value=
"
*.include "/home/user/pyvenvs/sky130venv/nodeset.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/set_sram_ham_small.spice"
"}
C {lab_pin.sym} 260 -2580 0 0 {name=p277 sig_type=std_logic lab=MAC_C[0..7]}
C {inv.sym} 430 -2690 0 0 {name=x34[0..7]}
C {lab_pin.sym} 430 -2710 0 1 {name=p278 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 430 -2670 0 1 {name=p279 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 490 -2690 2 0 {name=p280 sig_type=std_logic lab=MAC_C_bar[0..7]}
C {8T_sram_cell_c.sym} 1090 -2060 0 1 {name=xsram1}
C {lab_pin.sym} 940 -2120 0 0 {name=VCCsram1 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -2100 0 0 {name=WL0sram1 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 940 -2080 0 0 {name=BLB0sram1 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -2060 0 0 {name=BL0sram1 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -2040 0 0 {name=RBL0sram1 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -2020 0 0 {name=RWLsram1 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -2000 0 0 {name=VSSsram1 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -2060 0 1 {name=xsram2}
C {lab_pin.sym} 1230 -2120 0 0 {name=VCCsram2 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -2100 0 0 {name=WL0sram2 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1230 -2080 0 0 {name=BLB1sram2 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -2060 0 0 {name=BL1sram2 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -2040 0 0 {name=RBL1sram2 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -2020 0 0 {name=RWLsram2 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -2000 0 0 {name=VSSsram2 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -2060 0 1 {name=xsram3}
C {lab_pin.sym} 1520 -2120 0 0 {name=VCCsram3 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -2100 0 0 {name=WL0sram3 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1520 -2080 0 0 {name=BLB2sram3 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -2060 0 0 {name=BL2sram3 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -2040 0 0 {name=RBL2sram3 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -2020 0 0 {name=RWLsram3 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -2000 0 0 {name=VSSsram3 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -2060 0 1 {name=xsram4}
C {lab_pin.sym} 1810 -2120 0 0 {name=VCCsram4 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -2100 0 0 {name=WL0sram4 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1810 -2080 0 0 {name=BLB3sram4 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -2060 0 0 {name=BL3sram4 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -2040 0 0 {name=RBL3sram4 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -2020 0 0 {name=RWLsram4 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -2000 0 0 {name=VSSsram4 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -2060 0 1 {name=xsram5}
C {lab_pin.sym} 2100 -2120 0 0 {name=VCCsram5 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -2100 0 0 {name=WL0sram5 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2100 -2080 0 0 {name=BLB4sram5 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -2060 0 0 {name=BL4sram5 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -2040 0 0 {name=RBL4sram5 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -2020 0 0 {name=RWLsram5 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -2000 0 0 {name=VSSsram5 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -2060 0 1 {name=xsram6}
C {lab_pin.sym} 2390 -2120 0 0 {name=VCCsram6 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -2100 0 0 {name=WL0sram6 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2390 -2080 0 0 {name=BLB5sram6 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -2060 0 0 {name=BL5sram6 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -2040 0 0 {name=RBL5sram6 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -2020 0 0 {name=RWLsram6 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -2000 0 0 {name=VSSsram6 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -2060 0 1 {name=xsram7}
C {lab_pin.sym} 2680 -2120 0 0 {name=VCCsram7 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -2100 0 0 {name=WL0sram7 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2680 -2080 0 0 {name=BLB6sram7 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -2060 0 0 {name=BL6sram7 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -2040 0 0 {name=RBL6sram7 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -2020 0 0 {name=RWLsram7 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -2000 0 0 {name=VSSsram7 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -2060 0 1 {name=xsram8}
C {lab_pin.sym} 2970 -2120 0 0 {name=VCCsram8 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -2100 0 0 {name=WL0sram8 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2970 -2080 0 0 {name=BLB7sram8 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -2060 0 0 {name=BL7sram8 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -2040 0 0 {name=RBL7sram8 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -2020 0 0 {name=RWLsram8 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -2000 0 0 {name=VSSsram8 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1810 0 1 {name=xsram9}
C {lab_pin.sym} 940 -1870 0 0 {name=VCCsram9 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1850 0 0 {name=WL1sram9 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 940 -1830 0 0 {name=BLB0sram9 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -1810 0 0 {name=BL0sram9 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -1790 0 0 {name=RBL0sram9 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1770 0 0 {name=RWLsram9 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -1750 0 0 {name=VSSsram9 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1810 0 1 {name=xsram10}
C {lab_pin.sym} 1230 -1870 0 0 {name=VCCsram10 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1850 0 0 {name=WL1sram10 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1230 -1830 0 0 {name=BLB1sram10 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -1810 0 0 {name=BL1sram10 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -1790 0 0 {name=RBL1sram10 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -1770 0 0 {name=RWLsram10 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1750 0 0 {name=VSSsram10 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1810 0 1 {name=xsram11}
C {lab_pin.sym} 1520 -1870 0 0 {name=VCCsram11 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1850 0 0 {name=WL1sram11 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1520 -1830 0 0 {name=BLB2sram11 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -1810 0 0 {name=BL2sram11 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -1790 0 0 {name=RBL2sram11 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -1770 0 0 {name=RWLsram11 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1750 0 0 {name=VSSsram11 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1810 0 1 {name=xsram12}
C {lab_pin.sym} 1810 -1870 0 0 {name=VCCsram12 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1850 0 0 {name=WL1sram12 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1810 -1830 0 0 {name=BLB3sram12 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -1810 0 0 {name=BL3sram12 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -1790 0 0 {name=RBL3sram12 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -1770 0 0 {name=RWLsram12 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1750 0 0 {name=VSSsram12 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1810 0 1 {name=xsram13}
C {lab_pin.sym} 2100 -1870 0 0 {name=VCCsram13 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1850 0 0 {name=WL1sram13 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2100 -1830 0 0 {name=BLB4sram13 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -1810 0 0 {name=BL4sram13 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -1790 0 0 {name=RBL4sram13 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -1770 0 0 {name=RWLsram13 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1750 0 0 {name=VSSsram13 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1810 0 1 {name=xsram14}
C {lab_pin.sym} 2390 -1870 0 0 {name=VCCsram14 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1850 0 0 {name=WL1sram14 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2390 -1830 0 0 {name=BLB5sram14 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -1810 0 0 {name=BL5sram14 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -1790 0 0 {name=RBL5sram14 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -1770 0 0 {name=RWLsram14 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1750 0 0 {name=VSSsram14 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1810 0 1 {name=xsram15}
C {lab_pin.sym} 2680 -1870 0 0 {name=VCCsram15 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1850 0 0 {name=WL1sram15 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2680 -1830 0 0 {name=BLB6sram15 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -1810 0 0 {name=BL6sram15 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -1790 0 0 {name=RBL6sram15 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -1770 0 0 {name=RWLsram15 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1750 0 0 {name=VSSsram15 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1810 0 1 {name=xsram16}
C {lab_pin.sym} 2970 -1870 0 0 {name=VCCsram16 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1850 0 0 {name=WL1sram16 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2970 -1830 0 0 {name=BLB7sram16 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -1810 0 0 {name=BL7sram16 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -1790 0 0 {name=RBL7sram16 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -1770 0 0 {name=RWLsram16 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1750 0 0 {name=VSSsram16 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1560 0 1 {name=xsram17}
C {lab_pin.sym} 940 -1620 0 0 {name=VCCsram17 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1600 0 0 {name=WL2sram17 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 940 -1580 0 0 {name=BLB0sram17 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -1560 0 0 {name=BL0sram17 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -1540 0 0 {name=RBL0sram17 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1520 0 0 {name=RWLsram17 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -1500 0 0 {name=VSSsram17 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1560 0 1 {name=xsram18}
C {lab_pin.sym} 1230 -1620 0 0 {name=VCCsram18 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1600 0 0 {name=WL2sram18 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1230 -1580 0 0 {name=BLB1sram18 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -1560 0 0 {name=BL1sram18 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -1540 0 0 {name=RBL1sram18 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -1520 0 0 {name=RWLsram18 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1500 0 0 {name=VSSsram18 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1560 0 1 {name=xsram19}
C {lab_pin.sym} 1520 -1620 0 0 {name=VCCsram19 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1600 0 0 {name=WL2sram19 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1520 -1580 0 0 {name=BLB2sram19 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -1560 0 0 {name=BL2sram19 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -1540 0 0 {name=RBL2sram19 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -1520 0 0 {name=RWLsram19 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1500 0 0 {name=VSSsram19 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1560 0 1 {name=xsram20}
C {lab_pin.sym} 1810 -1620 0 0 {name=VCCsram20 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1600 0 0 {name=WL2sram20 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1810 -1580 0 0 {name=BLB3sram20 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -1560 0 0 {name=BL3sram20 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -1540 0 0 {name=RBL3sram20 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -1520 0 0 {name=RWLsram20 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1500 0 0 {name=VSSsram20 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1560 0 1 {name=xsram21}
C {lab_pin.sym} 2100 -1620 0 0 {name=VCCsram21 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1600 0 0 {name=WL2sram21 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2100 -1580 0 0 {name=BLB4sram21 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -1560 0 0 {name=BL4sram21 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -1540 0 0 {name=RBL4sram21 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -1520 0 0 {name=RWLsram21 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1500 0 0 {name=VSSsram21 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1560 0 1 {name=xsram22}
C {lab_pin.sym} 2390 -1620 0 0 {name=VCCsram22 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1600 0 0 {name=WL2sram22 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2390 -1580 0 0 {name=BLB5sram22 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -1560 0 0 {name=BL5sram22 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -1540 0 0 {name=RBL5sram22 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -1520 0 0 {name=RWLsram22 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1500 0 0 {name=VSSsram22 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1560 0 1 {name=xsram23}
C {lab_pin.sym} 2680 -1620 0 0 {name=VCCsram23 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1600 0 0 {name=WL2sram23 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2680 -1580 0 0 {name=BLB6sram23 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -1560 0 0 {name=BL6sram23 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -1540 0 0 {name=RBL6sram23 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -1520 0 0 {name=RWLsram23 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1500 0 0 {name=VSSsram23 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1560 0 1 {name=xsram24}
C {lab_pin.sym} 2970 -1620 0 0 {name=VCCsram24 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1600 0 0 {name=WL2sram24 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2970 -1580 0 0 {name=BLB7sram24 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -1560 0 0 {name=BL7sram24 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -1540 0 0 {name=RBL7sram24 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -1520 0 0 {name=RWLsram24 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1500 0 0 {name=VSSsram24 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1310 0 1 {name=xsram25}
C {lab_pin.sym} 940 -1370 0 0 {name=VCCsram25 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1350 0 0 {name=WL3sram25 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 940 -1330 0 0 {name=BLB0sram25 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -1310 0 0 {name=BL0sram25 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -1290 0 0 {name=RBL0sram25 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1270 0 0 {name=RWLsram25 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -1250 0 0 {name=VSSsram25 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1310 0 1 {name=xsram26}
C {lab_pin.sym} 1230 -1370 0 0 {name=VCCsram26 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1350 0 0 {name=WL3sram26 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1230 -1330 0 0 {name=BLB1sram26 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -1310 0 0 {name=BL1sram26 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -1290 0 0 {name=RBL1sram26 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -1270 0 0 {name=RWLsram26 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1250 0 0 {name=VSSsram26 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1310 0 1 {name=xsram27}
C {lab_pin.sym} 1520 -1370 0 0 {name=VCCsram27 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1350 0 0 {name=WL3sram27 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1520 -1330 0 0 {name=BLB2sram27 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -1310 0 0 {name=BL2sram27 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -1290 0 0 {name=RBL2sram27 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -1270 0 0 {name=RWLsram27 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1250 0 0 {name=VSSsram27 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1310 0 1 {name=xsram28}
C {lab_pin.sym} 1810 -1370 0 0 {name=VCCsram28 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1350 0 0 {name=WL3sram28 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1810 -1330 0 0 {name=BLB3sram28 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -1310 0 0 {name=BL3sram28 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -1290 0 0 {name=RBL3sram28 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -1270 0 0 {name=RWLsram28 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1250 0 0 {name=VSSsram28 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1310 0 1 {name=xsram29}
C {lab_pin.sym} 2100 -1370 0 0 {name=VCCsram29 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1350 0 0 {name=WL3sram29 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2100 -1330 0 0 {name=BLB4sram29 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -1310 0 0 {name=BL4sram29 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -1290 0 0 {name=RBL4sram29 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -1270 0 0 {name=RWLsram29 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1250 0 0 {name=VSSsram29 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1310 0 1 {name=xsram30}
C {lab_pin.sym} 2390 -1370 0 0 {name=VCCsram30 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1350 0 0 {name=WL3sram30 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2390 -1330 0 0 {name=BLB5sram30 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -1310 0 0 {name=BL5sram30 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -1290 0 0 {name=RBL5sram30 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -1270 0 0 {name=RWLsram30 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1250 0 0 {name=VSSsram30 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1310 0 1 {name=xsram31}
C {lab_pin.sym} 2680 -1370 0 0 {name=VCCsram31 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1350 0 0 {name=WL3sram31 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2680 -1330 0 0 {name=BLB6sram31 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -1310 0 0 {name=BL6sram31 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -1290 0 0 {name=RBL6sram31 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -1270 0 0 {name=RWLsram31 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1250 0 0 {name=VSSsram31 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1310 0 1 {name=xsram32}
C {lab_pin.sym} 2970 -1370 0 0 {name=VCCsram32 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1350 0 0 {name=WL3sram32 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2970 -1330 0 0 {name=BLB7sram32 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -1310 0 0 {name=BL7sram32 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -1290 0 0 {name=RBL7sram32 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -1270 0 0 {name=RWLsram32 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1250 0 0 {name=VSSsram32 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1060 0 1 {name=xsram33}
C {lab_pin.sym} 940 -1120 0 0 {name=VCCsram33 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1100 0 0 {name=WL4sram33 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 940 -1080 0 0 {name=BLB0sram33 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -1060 0 0 {name=BL0sram33 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -1040 0 0 {name=RBL0sram33 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1020 0 0 {name=RWLsram33 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -1000 0 0 {name=VSSsram33 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1060 0 1 {name=xsram34}
C {lab_pin.sym} 1230 -1120 0 0 {name=VCCsram34 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1100 0 0 {name=WL4sram34 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1230 -1080 0 0 {name=BLB1sram34 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -1060 0 0 {name=BL1sram34 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -1040 0 0 {name=RBL1sram34 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -1020 0 0 {name=RWLsram34 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1000 0 0 {name=VSSsram34 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1060 0 1 {name=xsram35}
C {lab_pin.sym} 1520 -1120 0 0 {name=VCCsram35 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1100 0 0 {name=WL4sram35 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1520 -1080 0 0 {name=BLB2sram35 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -1060 0 0 {name=BL2sram35 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -1040 0 0 {name=RBL2sram35 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -1020 0 0 {name=RWLsram35 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1000 0 0 {name=VSSsram35 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -1060 0 1 {name=xsram36}
C {lab_pin.sym} 1810 -1120 0 0 {name=VCCsram36 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1100 0 0 {name=WL4sram36 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1810 -1080 0 0 {name=BLB3sram36 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -1060 0 0 {name=BL3sram36 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -1040 0 0 {name=RBL3sram36 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -1020 0 0 {name=RWLsram36 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1000 0 0 {name=VSSsram36 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -1060 0 1 {name=xsram37}
C {lab_pin.sym} 2100 -1120 0 0 {name=VCCsram37 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1100 0 0 {name=WL4sram37 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2100 -1080 0 0 {name=BLB4sram37 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -1060 0 0 {name=BL4sram37 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -1040 0 0 {name=RBL4sram37 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -1020 0 0 {name=RWLsram37 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1000 0 0 {name=VSSsram37 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1060 0 1 {name=xsram38}
C {lab_pin.sym} 2390 -1120 0 0 {name=VCCsram38 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1100 0 0 {name=WL4sram38 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2390 -1080 0 0 {name=BLB5sram38 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -1060 0 0 {name=BL5sram38 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -1040 0 0 {name=RBL5sram38 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -1020 0 0 {name=RWLsram38 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1000 0 0 {name=VSSsram38 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1060 0 1 {name=xsram39}
C {lab_pin.sym} 2680 -1120 0 0 {name=VCCsram39 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1100 0 0 {name=WL4sram39 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2680 -1080 0 0 {name=BLB6sram39 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -1060 0 0 {name=BL6sram39 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -1040 0 0 {name=RBL6sram39 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -1020 0 0 {name=RWLsram39 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1000 0 0 {name=VSSsram39 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1060 0 1 {name=xsram40}
C {lab_pin.sym} 2970 -1120 0 0 {name=VCCsram40 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1100 0 0 {name=WL4sram40 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2970 -1080 0 0 {name=BLB7sram40 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -1060 0 0 {name=BL7sram40 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -1040 0 0 {name=RBL7sram40 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -1020 0 0 {name=RWLsram40 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1000 0 0 {name=VSSsram40 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -810 0 1 {name=xsram41}
C {lab_pin.sym} 940 -870 0 0 {name=VCCsram41 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -850 0 0 {name=WL5sram41 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 940 -830 0 0 {name=BLB0sram41 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -810 0 0 {name=BL0sram41 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -790 0 0 {name=RBL0sram41 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -770 0 0 {name=RWLsram41 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -750 0 0 {name=VSSsram41 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -810 0 1 {name=xsram42}
C {lab_pin.sym} 1230 -870 0 0 {name=VCCsram42 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -850 0 0 {name=WL5sram42 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1230 -830 0 0 {name=BLB1sram42 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -810 0 0 {name=BL1sram42 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -790 0 0 {name=RBL1sram42 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -770 0 0 {name=RWLsram42 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -750 0 0 {name=VSSsram42 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -810 0 1 {name=xsram43}
C {lab_pin.sym} 1520 -870 0 0 {name=VCCsram43 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -850 0 0 {name=WL5sram43 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1520 -830 0 0 {name=BLB2sram43 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -810 0 0 {name=BL2sram43 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -790 0 0 {name=RBL2sram43 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -770 0 0 {name=RWLsram43 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -750 0 0 {name=VSSsram43 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -810 0 1 {name=xsram44}
C {lab_pin.sym} 1810 -870 0 0 {name=VCCsram44 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -850 0 0 {name=WL5sram44 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1810 -830 0 0 {name=BLB3sram44 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -810 0 0 {name=BL3sram44 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -790 0 0 {name=RBL3sram44 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -770 0 0 {name=RWLsram44 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -750 0 0 {name=VSSsram44 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -810 0 1 {name=xsram45}
C {lab_pin.sym} 2100 -870 0 0 {name=VCCsram45 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -850 0 0 {name=WL5sram45 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2100 -830 0 0 {name=BLB4sram45 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -810 0 0 {name=BL4sram45 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -790 0 0 {name=RBL4sram45 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -770 0 0 {name=RWLsram45 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -750 0 0 {name=VSSsram45 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -810 0 1 {name=xsram46}
C {lab_pin.sym} 2390 -870 0 0 {name=VCCsram46 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -850 0 0 {name=WL5sram46 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2390 -830 0 0 {name=BLB5sram46 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -810 0 0 {name=BL5sram46 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -790 0 0 {name=RBL5sram46 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -770 0 0 {name=RWLsram46 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -750 0 0 {name=VSSsram46 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -810 0 1 {name=xsram47}
C {lab_pin.sym} 2680 -870 0 0 {name=VCCsram47 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -850 0 0 {name=WL5sram47 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2680 -830 0 0 {name=BLB6sram47 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -810 0 0 {name=BL6sram47 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -790 0 0 {name=RBL6sram47 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -770 0 0 {name=RWLsram47 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -750 0 0 {name=VSSsram47 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -810 0 1 {name=xsram48}
C {lab_pin.sym} 2970 -870 0 0 {name=VCCsram48 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -850 0 0 {name=WL5sram48 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2970 -830 0 0 {name=BLB7sram48 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -810 0 0 {name=BL7sram48 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -790 0 0 {name=RBL7sram48 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -770 0 0 {name=RWLsram48 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -750 0 0 {name=VSSsram48 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -560 0 1 {name=xsram49}
C {lab_pin.sym} 940 -620 0 0 {name=VCCsram49 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -600 0 0 {name=WL6sram49 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 940 -580 0 0 {name=BLB0sram49 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -560 0 0 {name=BL0sram49 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -540 0 0 {name=RBL0sram49 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -520 0 0 {name=RWLsram49 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -500 0 0 {name=VSSsram49 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -560 0 1 {name=xsram50}
C {lab_pin.sym} 1230 -620 0 0 {name=VCCsram50 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -600 0 0 {name=WL6sram50 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1230 -580 0 0 {name=BLB1sram50 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -560 0 0 {name=BL1sram50 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -540 0 0 {name=RBL1sram50 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -520 0 0 {name=RWLsram50 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -500 0 0 {name=VSSsram50 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -560 0 1 {name=xsram51}
C {lab_pin.sym} 1520 -620 0 0 {name=VCCsram51 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -600 0 0 {name=WL6sram51 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1520 -580 0 0 {name=BLB2sram51 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -560 0 0 {name=BL2sram51 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -540 0 0 {name=RBL2sram51 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -520 0 0 {name=RWLsram51 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -500 0 0 {name=VSSsram51 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -560 0 1 {name=xsram52}
C {lab_pin.sym} 1810 -620 0 0 {name=VCCsram52 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -600 0 0 {name=WL6sram52 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1810 -580 0 0 {name=BLB3sram52 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -560 0 0 {name=BL3sram52 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -540 0 0 {name=RBL3sram52 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -520 0 0 {name=RWLsram52 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -500 0 0 {name=VSSsram52 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -560 0 1 {name=xsram53}
C {lab_pin.sym} 2100 -620 0 0 {name=VCCsram53 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -600 0 0 {name=WL6sram53 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2100 -580 0 0 {name=BLB4sram53 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -560 0 0 {name=BL4sram53 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -540 0 0 {name=RBL4sram53 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -520 0 0 {name=RWLsram53 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -500 0 0 {name=VSSsram53 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -560 0 1 {name=xsram54}
C {lab_pin.sym} 2390 -620 0 0 {name=VCCsram54 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -600 0 0 {name=WL6sram54 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2390 -580 0 0 {name=BLB5sram54 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -560 0 0 {name=BL5sram54 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -540 0 0 {name=RBL5sram54 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -520 0 0 {name=RWLsram54 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -500 0 0 {name=VSSsram54 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -560 0 1 {name=xsram55}
C {lab_pin.sym} 2680 -620 0 0 {name=VCCsram55 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -600 0 0 {name=WL6sram55 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2680 -580 0 0 {name=BLB6sram55 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -560 0 0 {name=BL6sram55 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -540 0 0 {name=RBL6sram55 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -520 0 0 {name=RWLsram55 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -500 0 0 {name=VSSsram55 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -560 0 1 {name=xsram56}
C {lab_pin.sym} 2970 -620 0 0 {name=VCCsram56 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -600 0 0 {name=WL6sram56 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2970 -580 0 0 {name=BLB7sram56 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -560 0 0 {name=BL7sram56 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -540 0 0 {name=RBL7sram56 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -520 0 0 {name=RWLsram56 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -500 0 0 {name=VSSsram56 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -310 0 1 {name=xsram57}
C {lab_pin.sym} 940 -370 0 0 {name=VCCsram57 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -350 0 0 {name=WL7sram57 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 940 -330 0 0 {name=BLB0sram57 sig_type=std_logic lab=BLB0}
C {lab_pin.sym} 940 -310 0 0 {name=BL0sram57 sig_type=std_logic lab=BL0}
C {lab_pin.sym} 940 -290 0 0 {name=RBL0sram57 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -270 0 0 {name=RWLsram57 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 940 -250 0 0 {name=VSSsram57 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -310 0 1 {name=xsram58}
C {lab_pin.sym} 1230 -370 0 0 {name=VCCsram58 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -350 0 0 {name=WL7sram58 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1230 -330 0 0 {name=BLB1sram58 sig_type=std_logic lab=BLB1}
C {lab_pin.sym} 1230 -310 0 0 {name=BL1sram58 sig_type=std_logic lab=BL1}
C {lab_pin.sym} 1230 -290 0 0 {name=RBL1sram58 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -270 0 0 {name=RWLsram58 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -250 0 0 {name=VSSsram58 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -310 0 1 {name=xsram59}
C {lab_pin.sym} 1520 -370 0 0 {name=VCCsram59 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -350 0 0 {name=WL7sram59 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1520 -330 0 0 {name=BLB2sram59 sig_type=std_logic lab=BLB2}
C {lab_pin.sym} 1520 -310 0 0 {name=BL2sram59 sig_type=std_logic lab=BL2}
C {lab_pin.sym} 1520 -290 0 0 {name=RBL2sram59 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -270 0 0 {name=RWLsram59 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -250 0 0 {name=VSSsram59 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -310 0 1 {name=xsram60}
C {lab_pin.sym} 1810 -370 0 0 {name=VCCsram60 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -350 0 0 {name=WL7sram60 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1810 -330 0 0 {name=BLB3sram60 sig_type=std_logic lab=BLB3}
C {lab_pin.sym} 1810 -310 0 0 {name=BL3sram60 sig_type=std_logic lab=BL3}
C {lab_pin.sym} 1810 -290 0 0 {name=RBL3sram60 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -270 0 0 {name=RWLsram60 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -250 0 0 {name=VSSsram60 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -310 0 1 {name=xsram61}
C {lab_pin.sym} 2100 -370 0 0 {name=VCCsram61 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -350 0 0 {name=WL7sram61 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2100 -330 0 0 {name=BLB4sram61 sig_type=std_logic lab=BLB4}
C {lab_pin.sym} 2100 -310 0 0 {name=BL4sram61 sig_type=std_logic lab=BL4}
C {lab_pin.sym} 2100 -290 0 0 {name=RBL4sram61 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -270 0 0 {name=RWLsram61 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -250 0 0 {name=VSSsram61 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -310 0 1 {name=xsram62}
C {lab_pin.sym} 2390 -370 0 0 {name=VCCsram62 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -350 0 0 {name=WL7sram62 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2390 -330 0 0 {name=BLB5sram62 sig_type=std_logic lab=BLB5}
C {lab_pin.sym} 2390 -310 0 0 {name=BL5sram62 sig_type=std_logic lab=BL5}
C {lab_pin.sym} 2390 -290 0 0 {name=RBL5sram62 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -270 0 0 {name=RWLsram62 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -250 0 0 {name=VSSsram62 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -310 0 1 {name=xsram63}
C {lab_pin.sym} 2680 -370 0 0 {name=VCCsram63 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -350 0 0 {name=WL7sram63 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2680 -330 0 0 {name=BLB6sram63 sig_type=std_logic lab=BLB6}
C {lab_pin.sym} 2680 -310 0 0 {name=BL6sram63 sig_type=std_logic lab=BL6}
C {lab_pin.sym} 2680 -290 0 0 {name=RBL6sram63 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -270 0 0 {name=RWLsram63 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -250 0 0 {name=VSSsram63 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -310 0 1 {name=xsram64}
C {lab_pin.sym} 2970 -370 0 0 {name=VCCsram64 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -350 0 0 {name=WL7sram64 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2970 -330 0 0 {name=BLB7sram64 sig_type=std_logic lab=BLB7}
C {lab_pin.sym} 2970 -310 0 0 {name=BL7sram64 sig_type=std_logic lab=BL7}
C {lab_pin.sym} 2970 -290 0 0 {name=RBL7sram64 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -270 0 0 {name=RWLsram64 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -250 0 0 {name=VSSsram64 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 840 -2890 0 0 {name=xmac_dec1}
C {lab_pin.sym} 990 -2970 0 1 {name=p_vcc_0 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 990 -2950 0 1 {name=p_vss_top_0 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 990 -2930 0 1 {name=p_clk_0 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 990 -2910 0 1 {name=p_clk_bar_0 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 990 -2890 0 1 {name=p_rbl_sym_0 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 990 -2870 0 1 {name=p_tr_0 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 990 -2850 0 1 {name=p_mac_c_0 sig_type=std_logic lab=MAC_C0}
C {lab_pin.sym} 990 -2830 0 1 {name=p_mac_en_0 lab=MAC_EN}
C {lab_pin.sym} 990 -2810 0 1 {name=p_mac_en_bar_0 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 940 -3090 0 0 {name=C_mac1 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 960 -3240 2 0 {name=M_mac1
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 940 -3270 0 1 {name=p_vss_gate_0 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1000 -3240 0 1 {name=p_pre_0 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 990 -3150 0 1 {name=p_rbl_nfet_0 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -3060 0 1 {name=p_vss_cap_0 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 1130 -2890 0 0 {name=xmac_dec2}
C {lab_pin.sym} 1280 -2970 0 1 {name=p_vcc_1 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1280 -2950 0 1 {name=p_vss_top_1 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1280 -2930 0 1 {name=p_clk_1 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1280 -2910 0 1 {name=p_clk_bar_1 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1280 -2890 0 1 {name=p_rbl_sym_1 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1280 -2870 0 1 {name=p_tr_1 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 1280 -2850 0 1 {name=p_mac_c_1 sig_type=std_logic lab=MAC_C1}
C {lab_pin.sym} 1280 -2830 0 1 {name=p_mac_en_1 lab=MAC_EN}
C {lab_pin.sym} 1280 -2810 0 1 {name=p_mac_en_bar_1 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1230 -3090 0 0 {name=C_mac2 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1250 -3240 2 0 {name=M_mac2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1230 -3270 0 1 {name=p_vss_gate_1 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1290 -3240 0 1 {name=p_pre_1 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 1280 -3150 0 1 {name=p_rbl_nfet_1 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 1230 -3060 0 1 {name=p_vss_cap_1 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 1420 -2890 0 0 {name=xmac_dec3}
C {lab_pin.sym} 1570 -2970 0 1 {name=p_vcc_2 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1570 -2950 0 1 {name=p_vss_top_2 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1570 -2930 0 1 {name=p_clk_2 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1570 -2910 0 1 {name=p_clk_bar_2 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1570 -2890 0 1 {name=p_rbl_sym_2 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1570 -2870 0 1 {name=p_tr_2 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 1570 -2850 0 1 {name=p_mac_c_2 sig_type=std_logic lab=MAC_C2}
C {lab_pin.sym} 1570 -2830 0 1 {name=p_mac_en_2 lab=MAC_EN}
C {lab_pin.sym} 1570 -2810 0 1 {name=p_mac_en_bar_2 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1520 -3090 0 0 {name=C_mac3 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1540 -3240 2 0 {name=M_mac3
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1520 -3270 0 1 {name=p_vss_gate_2 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1580 -3240 0 1 {name=p_pre_2 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 1570 -3150 0 1 {name=p_rbl_nfet_2 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1520 -3060 0 1 {name=p_vss_cap_2 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 1710 -2890 0 0 {name=xmac_dec4}
C {lab_pin.sym} 1860 -2970 0 1 {name=p_vcc_3 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1860 -2950 0 1 {name=p_vss_top_3 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1860 -2930 0 1 {name=p_clk_3 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1860 -2910 0 1 {name=p_clk_bar_3 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1860 -2890 0 1 {name=p_rbl_sym_3 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1860 -2870 0 1 {name=p_tr_3 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 1860 -2850 0 1 {name=p_mac_c_3 sig_type=std_logic lab=MAC_C3}
C {lab_pin.sym} 1860 -2830 0 1 {name=p_mac_en_3 lab=MAC_EN}
C {lab_pin.sym} 1860 -2810 0 1 {name=p_mac_en_bar_3 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1810 -3090 0 0 {name=C_mac4 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1830 -3240 2 0 {name=M_mac4
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1810 -3270 0 1 {name=p_vss_gate_3 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1870 -3240 0 1 {name=p_pre_3 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 1860 -3150 0 1 {name=p_rbl_nfet_3 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1810 -3060 0 1 {name=p_vss_cap_3 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 2000 -2890 0 0 {name=xmac_dec5}
C {lab_pin.sym} 2150 -2970 0 1 {name=p_vcc_4 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2150 -2950 0 1 {name=p_vss_top_4 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2150 -2930 0 1 {name=p_clk_4 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2150 -2910 0 1 {name=p_clk_bar_4 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2150 -2890 0 1 {name=p_rbl_sym_4 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2150 -2870 0 1 {name=p_tr_4 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 2150 -2850 0 1 {name=p_mac_c_4 sig_type=std_logic lab=MAC_C4}
C {lab_pin.sym} 2150 -2830 0 1 {name=p_mac_en_4 lab=MAC_EN}
C {lab_pin.sym} 2150 -2810 0 1 {name=p_mac_en_bar_4 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2100 -3090 0 0 {name=C_mac5 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 2120 -3240 2 0 {name=M_mac5
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2100 -3270 0 1 {name=p_vss_gate_4 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2160 -3240 0 1 {name=p_pre_4 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 2150 -3150 0 1 {name=p_rbl_nfet_4 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -3060 0 1 {name=p_vss_cap_4 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 2290 -2890 0 0 {name=xmac_dec6}
C {lab_pin.sym} 2440 -2970 0 1 {name=p_vcc_5 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2440 -2950 0 1 {name=p_vss_top_5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2440 -2930 0 1 {name=p_clk_5 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2440 -2910 0 1 {name=p_clk_bar_5 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2440 -2890 0 1 {name=p_rbl_sym_5 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2440 -2870 0 1 {name=p_tr_5 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 2440 -2850 0 1 {name=p_mac_c_5 sig_type=std_logic lab=MAC_C5}
C {lab_pin.sym} 2440 -2830 0 1 {name=p_mac_en_5 lab=MAC_EN}
C {lab_pin.sym} 2440 -2810 0 1 {name=p_mac_en_bar_5 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -3090 0 0 {name=C_mac6 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 2410 -3240 2 0 {name=M_mac6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2390 -3270 0 1 {name=p_vss_gate_5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2450 -3240 0 1 {name=p_pre_5 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 2440 -3150 0 1 {name=p_rbl_nfet_5 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2390 -3060 0 1 {name=p_vss_cap_5 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 2580 -2890 0 0 {name=xmac_dec7}
C {lab_pin.sym} 2730 -2970 0 1 {name=p_vcc_6 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2730 -2950 0 1 {name=p_vss_top_6 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2730 -2930 0 1 {name=p_clk_6 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2730 -2910 0 1 {name=p_clk_bar_6 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2730 -2890 0 1 {name=p_rbl_sym_6 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2730 -2870 0 1 {name=p_tr_6 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 2730 -2850 0 1 {name=p_mac_c_6 sig_type=std_logic lab=MAC_C6}
C {lab_pin.sym} 2730 -2830 0 1 {name=p_mac_en_6 lab=MAC_EN}
C {lab_pin.sym} 2730 -2810 0 1 {name=p_mac_en_bar_6 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2680 -3090 0 0 {name=C_mac7 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 2700 -3240 2 0 {name=M_mac7
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2680 -3270 0 1 {name=p_vss_gate_6 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2740 -3240 0 1 {name=p_pre_6 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 2730 -3150 0 1 {name=p_rbl_nfet_6 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2680 -3060 0 1 {name=p_vss_cap_6 sig_type=std_logic lab=VSS}
C {voltage_comp/MAC_decoder_7.sym} 2870 -2890 0 0 {name=xmac_dec8}
C {lab_pin.sym} 3020 -2970 0 1 {name=p_vcc_7 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 3020 -2950 0 1 {name=p_vss_top_7 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3020 -2930 0 1 {name=p_clk_7 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 3020 -2910 0 1 {name=p_clk_bar_7 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 3020 -2890 0 1 {name=p_rbl_sym_7 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 3020 -2870 0 1 {name=p_tr_7 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 3020 -2850 0 1 {name=p_mac_c_7 sig_type=std_logic lab=MAC_C7}
C {lab_pin.sym} 3020 -2830 0 1 {name=p_mac_en_7 lab=MAC_EN}
C {lab_pin.sym} 3020 -2810 0 1 {name=p_mac_en_bar_7 sig_type=std_logic lab=MAC_EN_bar}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 -3090 0 0 {name=C_mac8 model=cap_mim_m3_1 W=210 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 2990 -3240 2 0 {name=M_mac8
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2970 -3270 0 1 {name=p_vss_gate_7 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3030 -3240 0 1 {name=p_pre_7 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 3020 -3150 0 1 {name=p_rbl_nfet_7 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2970 -3060 0 1 {name=p_vss_cap_7 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -2520 0 1 {name=xsram_ham1}
C {lab_pin.sym} 940 -2580 0 0 {name=VCCsram_ham1 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -2560 0 0 {name=WL0sram_ham1 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 940 -2540 0 0 {name=MAC_C_bar0sram_ham1 sig_type=std_logic lab=MAC_C_bar0}
C {lab_pin.sym} 940 -2520 0 0 {name=MAC_C0sram_ham1 sig_type=std_logic lab=MACf_C0}
C {lab_pin.sym} 940 -2500 0 0 {name=MACRBLsram_ham1 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 940 -2480 0 0 {name=MACRWLsram_ham1 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 940 -2460 0 0 {name=VSSsram_ham1 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -2520 0 1 {name=xsram_ham2}
C {lab_pin.sym} 1230 -2580 0 0 {name=VCCsram_ham2 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -2560 0 0 {name=WL0sram_ham2 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1230 -2540 0 0 {name=MAC_C_bar1sram_ham2 sig_type=std_logic lab=MAC_C_bar1}
C {lab_pin.sym} 1230 -2520 0 0 {name=MAC_C1sram_ham2 sig_type=std_logic lab=MACf_C1}
C {lab_pin.sym} 1230 -2500 0 0 {name=MACRBLsram_ham2 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1230 -2480 0 0 {name=MACRWLsram_ham2 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1230 -2460 0 0 {name=VSSsram_ham2 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -2520 0 1 {name=xsram_ham3}
C {lab_pin.sym} 1520 -2580 0 0 {name=VCCsram_ham3 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -2560 0 0 {name=WL0sram_ham3 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1520 -2540 0 0 {name=MAC_C_bar2sram_ham3 sig_type=std_logic lab=MAC_C_bar2}
C {lab_pin.sym} 1520 -2520 0 0 {name=MAC_C2sram_ham3 sig_type=std_logic lab=MACf_C2}
C {lab_pin.sym} 1520 -2500 0 0 {name=MACRBLsram_ham3 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1520 -2480 0 0 {name=MACRWLsram_ham3 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1520 -2460 0 0 {name=VSSsram_ham3 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1960 -2520 0 1 {name=xsram_ham4}
C {lab_pin.sym} 1810 -2580 0 0 {name=VCCsram_ham4 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -2560 0 0 {name=WL0sram_ham4 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1810 -2540 0 0 {name=MAC_C_bar3sram_ham4 sig_type=std_logic lab=MAC_C_bar3}
C {lab_pin.sym} 1810 -2520 0 0 {name=MAC_C3sram_ham4 sig_type=std_logic lab=MACf_C3}
C {lab_pin.sym} 1810 -2500 0 0 {name=MACRBLsram_ham4 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1810 -2480 0 0 {name=MACRWLsram_ham4 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1810 -2460 0 0 {name=VSSsram_ham4 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2250 -2520 0 1 {name=xsram_ham5}
C {lab_pin.sym} 2100 -2580 0 0 {name=VCCsram_ham5 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -2560 0 0 {name=WL0sram_ham5 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2100 -2540 0 0 {name=MAC_C_bar4sram_ham5 sig_type=std_logic lab=MAC_C_bar4}
C {lab_pin.sym} 2100 -2520 0 0 {name=MAC_C4sram_ham5 sig_type=std_logic lab=MACf_C4}
C {lab_pin.sym} 2100 -2500 0 0 {name=MACRBLsram_ham5 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2100 -2480 0 0 {name=MACRWLsram_ham5 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2100 -2460 0 0 {name=VSSsram_ham5 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -2520 0 1 {name=xsram_ham6}
C {lab_pin.sym} 2390 -2580 0 0 {name=VCCsram_ham6 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -2560 0 0 {name=WL0sram_ham6 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2390 -2540 0 0 {name=MAC_C_bar5sram_ham6 sig_type=std_logic lab=MAC_C_bar5}
C {lab_pin.sym} 2390 -2520 0 0 {name=MAC_C5sram_ham6 sig_type=std_logic lab=MACf_C5}
C {lab_pin.sym} 2390 -2500 0 0 {name=MACRBLsram_ham6 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2390 -2480 0 0 {name=MACRWLsram_ham6 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2390 -2460 0 0 {name=VSSsram_ham6 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -2520 0 1 {name=xsram_ham7}
C {lab_pin.sym} 2680 -2580 0 0 {name=VCCsram_ham7 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -2560 0 0 {name=WL0sram_ham7 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2680 -2540 0 0 {name=MAC_C_bar6sram_ham7 sig_type=std_logic lab=MAC_C_bar6}
C {lab_pin.sym} 2680 -2520 0 0 {name=MAC_C6sram_ham7 sig_type=std_logic lab=MACf_C6}
C {lab_pin.sym} 2680 -2500 0 0 {name=MACRBLsram_ham7 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2680 -2480 0 0 {name=MACRWLsram_ham7 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2680 -2460 0 0 {name=VSSsram_ham7 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -2520 0 1 {name=xsram_ham8}
C {lab_pin.sym} 2970 -2580 0 0 {name=VCCsram_ham8 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -2560 0 0 {name=WL0sram_ham8 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2970 -2540 0 0 {name=MAC_C_bar7sram_ham8 sig_type=std_logic lab=MAC_C_bar7}
C {lab_pin.sym} 2970 -2520 0 0 {name=MAC_C7sram_ham8 sig_type=std_logic lab=MACf_C7}
C {lab_pin.sym} 2970 -2500 0 0 {name=MACRBLsram_ham8 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2970 -2480 0 0 {name=MACRWLsram_ham8 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2970 -2460 0 0 {name=VSSsram_ham8 sig_type=std_logic lab=VSS}
C {launcher.sym} 30 -3150 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/ham_real_PART1&2_b.raw tran"
}
C {voltage_comp/MAC_decoder_7.sym} 50 -620 0 0 {name=xham_dec}
C {lab_pin.sym} 200 -700 0 1 {name=p_vcc_8 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 200 -680 0 1 {name=p_vss_top_8 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 200 -660 0 1 {name=p_clk_8 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 200 -640 0 1 {name=p_clk_bar_8 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 200 -620 0 1 {name=p_rbl_sym_8 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 200 -600 0 1 {name=p_tr_8 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 200 -580 0 1 {name=p_mac sig_type=std_logic lab=MAC[8..0]}
C {lab_pin.sym} 200 -560 0 1 {name=p_mac_en_8 lab=MAC_EN}
C {lab_pin.sym} 200 -540 0 1 {name=p_mac_en_bar_8 sig_type=std_logic lab=MAC_EN_bar}
C {inv.sym} 310 -2690 0 0 {name=x1[0..7]}
C {lab_pin.sym} 310 -2710 0 1 {name=p1 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 310 -2670 0 1 {name=p2 sig_type=std_logic lab=VSS}
C {inv.sym} 190 -2690 0 0 {name=x2[0..7]}
C {lab_pin.sym} 190 -2710 0 1 {name=p3 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 190 -2670 0 1 {name=p4 sig_type=std_logic lab=VSS}
C {inv.sym} 440 -2580 0 0 {name=x3[0..7]}
C {lab_pin.sym} 440 -2600 0 1 {name=p5 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 440 -2560 0 1 {name=p6 sig_type=std_logic lab=VSS}
C {inv.sym} 320 -2580 0 0 {name=x4[0..7]}
C {lab_pin.sym} 320 -2600 0 1 {name=p9 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 320 -2560 0 1 {name=p10 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 130 -2690 0 0 {name=p11 sig_type=std_logic lab=MAC_C[0..7]}
C {lab_pin.sym} 500 -2580 0 1 {name=p12 sig_type=std_logic lab=MACf_C[0..7]}
