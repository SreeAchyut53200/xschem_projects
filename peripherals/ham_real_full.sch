v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -940 -3380 -140 -2980 {flags=graph
y1=-0.027
y2=1.9
ypos1=0.18679143
ypos2=2.1137916
divy=5
subdivy=1
unity=1
x1=5.5064878e-08
x2=1.6711725e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=1
legend=1
sim_type=tran
color="4 5 6 7 8 9 10 11 12 13 14 15 16 17 18"
node="en
pre
rwl
macrwl
mac_en
ROW1;x44.q,x43.q,x42.q,x41.q,x4.q,x3.q,x2.q,x1.q
ROW2;x48.q,x47.q,x46.q,x13.q,x45.q,x12.q,x11.q,x10.q
ROW3;x52.q,x51.q,x50.q,x49.q,x8.q,x7.q,x6.q,x5.q
ROW4;x56.q,x55.q,x54.q,x53.q,x16.q,x15.q,x14.q,x9.q
ROW5;x60.q,x59.q,x58.q,x57.q,x24.q,x23.q,x22.q,x21.q
ROW6;x64.q,x63.q,x62.q,x61.q,x32.q,x31.q,x30.q,x25.q
ROW7;x68.q,x67.q,x66.q,x65.q,x36.q,x35.q,x34.q,x33.q
ROW8;x72.q,x71.q,x70.q,x69.q,x40.q,x39.q,x38.q,x37.q

ROW9;x76.q,x75.q,x74.q,x73.q,x29.q,x28.q,x27.q,x26.q
row9_bar;x29.q_bar,x28.q_bar,x27.q_bar,x26.q_bar"}
B 2 -1760 -2440 -960 -2040 {flags=graph,unlocked
y1=-0.027
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=0
x2=8.7e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=1
color="4 5 6 7 8 9 10 11 7 7 7 7"
node="bl7
bl6
bl5
bl4
bl3
bl2
bl1
bl0


blb3
blb2
blb1
blb0"
hilight_wave=-1}
B 2 -1760 -2910 -960 -2510 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-6.5639214e-09
x2=1.0548843e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="S;s2,s1,s0
en
pre
rwl
clk
mac_en
macrwl"
color="4 5 6 7 8 9 10"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=4
digital=1}
B 2 -1760 -3380 -960 -2980 {flags=graph
y1=-0.059
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.5064878e-08
x2=1.6711725e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=1
hilight_wave=-1
sim_type=tran
color="4 7 7 9 9 6 6 11 11 5 5 8 8 20 20 21 21"
node="clk
x17.net1_1
x17.net1_0
x18.net1_1
x18.net1_0
x19.net1_1
x19.net1_0
x20.net1_1
x20.net1_0
x79.net1_1
x79.net1_0
x78.net1_1
x78.net1_0
x80.net1_1
x80.net1_0
x81.net1_1
x81.net1_0"}
B 2 -940 -2440 -140 -2040 {flags=graph
y1=-0.052
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.5064878e-08
x2=1.6711725e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=1
hilight_wave=6
node="S;s2,s1,s0
en
pre
rwl
clk
mac_en
macrwl"
sim_type=tran
color="4 5 6 7 8 9 10"}
B 2 -30 -3170 770 -2770 {flags=graph
y1=-0.17618
y2=2.91054
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.5064878e-08
x2=1.6711725e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=0
hilight_wave=0
sim_type=tran
color="4 5"
node="x81.x1.x1.out+
x81.x1.x1.out-"}
B 2 -940 -2910 -140 -2510 {flags=graph
y1=1.719514
y2=1.8721642
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=5.5064878e-08
x2=1.6711725e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/ham_real_full.raw
autoload=0
digital=0
hilight_wave=3
sim_type=tran
color="4 5 6 7 8 9 10 11 12 13 13 13 13 13 13 13 13 13"
node="rbl7
rbl6
rbl5
rbl4
rbl3
rbl2
rbl1
rbl0
macrbl
clk

tr7
tr6
tr5
tr4
tr3
tr2
tr1
tr0"}
N 940 -3210 940 -3120 {lab=RBL0}
N 940 -3150 990 -3150 {lab=RBL0}
N 940 -3290 940 -3270 {lab=GND}
N 940 -3240 950 -3240 {lab=GND}
N 950 -3280 950 -3240 {lab=GND}
N 940 -3280 950 -3280 {lab=GND}
N 880 -3240 900 -3240 {lab=PRE}
N 850 -2250 3120 -2250 {lab=BL[0..7]
bus=true}
N 850 -2200 3120 -2200 {lab=BLB[0..7]
bus=true}
N 880 -2190 880 -2080 {lab=BLB0}
N 880 -2080 940 -2080 {lab=BLB0}
N 860 -2240 860 -2060 {lab=BL0
bus}
N 860 -2060 940 -2060 {lab=BL0}
N 1170 -2190 1170 -2080 {lab=BLB1}
N 1170 -2080 1230 -2080 {lab=BLB1}
N 1150 -2240 1150 -2060 {lab=BL1}
N 1150 -2060 1230 -2060 {lab=BL1}
N 1460 -2190 1460 -2080 {lab=BLB2}
N 1460 -2080 1520 -2080 {lab=BLB2}
N 1440 -2240 1440 -2060 {lab=BL2}
N 1440 -2060 1520 -2060 {lab=BL2}
N 1750 -2190 1750 -2080 {lab=BLB3}
N 1750 -2080 1810 -2080 {lab=BLB3}
N 1730 -2240 1730 -2060 {lab=BL3}
N 1730 -2060 1810 -2060 {lab=BL3}
N 200 -1670 200 -1480 {lab=WL[0..7]
bus=true}
N 150 -1640 190 -1640 {lab=WL7}
N 150 -1620 190 -1620 {lab=WL6}
N 150 -1600 190 -1600 {lab=WL5}
N 150 -1580 190 -1580 {lab=WL4}
N 150 -1560 190 -1560 {lab=WL3}
N 150 -1540 190 -1540 {lab=WL2}
N 150 -1520 190 -1520 {lab=WL1}
N 150 -1500 190 -1500 {lab=WL0}
N 860 -2060 860 -1810 {lab=BL0}
N 860 -1810 940 -1810 {lab=BL0}
N 880 -2080 880 -1830 {lab=BLB0}
N 880 -1830 940 -1830 {lab=BLB0}
N 1150 -2060 1150 -1810 {lab=BL1}
N 1150 -1810 1230 -1810 {lab=BL1}
N 1170 -2080 1170 -1830 {lab=BLB1}
N 1170 -1830 1230 -1830 {lab=BLB1}
N 1440 -2060 1440 -1810 {lab=BL2}
N 1440 -1810 1520 -1810 {lab=BL2}
N 1460 -2080 1460 -1830 {lab=BLB2}
N 1460 -1830 1520 -1830 {lab=BLB2}
N 1730 -2060 1730 -1810 {lab=BL3}
N 1730 -1810 1810 -1810 {lab=BL3}
N 1750 -2080 1750 -1830 {lab=BLB3}
N 1750 -1830 1810 -1830 {lab=BLB3}
N 1230 -3210 1230 -3120 {lab=RBL1}
N 1230 -3150 1280 -3150 {lab=RBL1}
N 1230 -3290 1230 -3270 {lab=GND}
N 1230 -3240 1240 -3240 {lab=GND}
N 1240 -3280 1240 -3240 {lab=GND}
N 1230 -3280 1240 -3280 {lab=GND}
N 1170 -3240 1190 -3240 {lab=PRE}
N 1520 -3210 1520 -3120 {lab=RBL2}
N 1520 -3150 1570 -3150 {lab=RBL2}
N 1520 -3290 1520 -3270 {lab=GND}
N 1520 -3240 1530 -3240 {lab=GND}
N 1530 -3280 1530 -3240 {lab=GND}
N 1520 -3280 1530 -3280 {lab=GND}
N 1460 -3240 1480 -3240 {lab=PRE}
N 1810 -3210 1810 -3120 {lab=RBL3}
N 1810 -3290 1810 -3270 {lab=GND}
N 1810 -3240 1820 -3240 {lab=GND}
N 1820 -3280 1820 -3240 {lab=GND}
N 1810 -3280 1820 -3280 {lab=GND}
N 1750 -3240 1770 -3240 {lab=PRE}
N 1810 -3150 1860 -3150 {lab=RBL3}
N 820 320 900 320 {lab=MACC0}
N 840 300 900 300 {lab=MAC2_barC0}
N 1110 320 1190 320 {lab=MACC1}
N 1130 300 1190 300 {lab=MAC2_barC1}
N 1400 320 1480 320 {lab=MACC2}
N 1420 300 1480 300 {lab=MAC2_barC2}
N 1690 320 1770 320 {lab=MACC3}
N 1710 300 1770 300 {lab=MAC2_barC3}
N 3530 -1510 3530 -1420 {lab=MACRBL}
N 3530 -1450 3580 -1450 {lab=MACRBL}
N 3530 -1590 3530 -1570 {lab=GND}
N 3530 -1540 3540 -1540 {lab=GND}
N 3540 -1580 3540 -1540 {lab=GND}
N 3530 -1580 3540 -1580 {lab=GND}
N 3470 -1540 3490 -1540 {lab=PRE}
N 790 40 2910 40 {lab=MAC2_barC[0..7]
bus=true}
N 840 50 840 300 {lab=MAC2_barC0}
N 1130 50 1130 300 {lab=MAC2_barC1}
N 1420 50 1420 300 {lab=MAC2_barC2}
N 1710 50 1710 300 {lab=MAC2_barC3}
N 680 200 2890 200 {lab=MACC[0..7]
bus=true}
N 820 210 820 320 {lab=MACC0}
N 1110 210 1110 320 {lab=MACC1}
N 1400 210 1400 320 {lab=MACC2}
N 1690 210 1690 320 {lab=MACC3}
N 810 -60 810 -10 {lab=MAC2_barC[0..7]}
N 810 -10 810 40 {lab=MAC2_barC[0..7]}
N 860 -1810 860 -1560 {lab=BL0}
N 860 -1560 940 -1560 {lab=BL0}
N 880 -1830 880 -1580 {lab=BLB0}
N 880 -1580 940 -1580 {lab=BLB0}
N 1150 -1810 1150 -1560 {lab=BL1}
N 1150 -1560 1230 -1560 {lab=BL1}
N 1170 -1830 1170 -1580 {lab=BLB1}
N 1170 -1580 1230 -1580 {lab=BLB1}
N 1440 -1810 1440 -1560 {lab=BL2}
N 1440 -1560 1520 -1560 {lab=BL2}
N 1460 -1830 1460 -1580 {lab=BLB2}
N 1460 -1580 1520 -1580 {lab=BLB2}
N 1730 -1810 1730 -1560 {lab=BL3}
N 1730 -1560 1810 -1560 {lab=BL3}
N 1750 -1830 1750 -1580 {lab=BLB3}
N 1750 -1580 1810 -1580 {lab=BLB3}
N 860 -1560 860 -1310 {lab=BL0}
N 860 -1310 940 -1310 {lab=BL0}
N 880 -1580 880 -1330 {lab=BLB0}
N 880 -1330 940 -1330 {lab=BLB0}
N 1150 -1560 1150 -1310 {lab=BL1}
N 1150 -1310 1230 -1310 {lab=BL1}
N 1170 -1580 1170 -1330 {lab=BLB1}
N 1170 -1330 1230 -1330 {lab=BLB1}
N 1440 -1560 1440 -1310 {lab=BL2}
N 1440 -1310 1520 -1310 {lab=BL2}
N 1460 -1580 1460 -1330 {lab=BLB2}
N 1460 -1330 1520 -1330 {lab=BLB2}
N 1730 -1560 1730 -1310 {lab=BL3}
N 1730 -1310 1810 -1310 {lab=BL3}
N 1750 -1580 1750 -1330 {lab=BLB3}
N 1750 -1330 1810 -1330 {lab=BLB3}
N 860 -1310 860 -1060 {lab=BL0}
N 860 -1060 940 -1060 {lab=BL0}
N 880 -1330 880 -1080 {lab=BLB0}
N 880 -1080 940 -1080 {lab=BLB0}
N 1150 -1310 1150 -1060 {lab=BL1}
N 1150 -1060 1230 -1060 {lab=BL1}
N 1170 -1330 1170 -1080 {lab=BLB1}
N 1170 -1080 1230 -1080 {lab=BLB1}
N 1440 -1310 1440 -1060 {lab=BL2}
N 1440 -1060 1520 -1060 {lab=BL2}
N 1460 -1330 1460 -1080 {lab=BLB2}
N 1460 -1080 1520 -1080 {lab=BLB2}
N 1730 -1310 1730 -1060 {lab=BL3}
N 1730 -1060 1810 -1060 {lab=BL3}
N 1750 -1330 1750 -1080 {lab=BLB3}
N 1750 -1080 1810 -1080 {lab=BLB3}
N 860 -1060 860 -810 {lab=BL0}
N 860 -810 940 -810 {lab=BL0}
N 880 -1080 880 -830 {lab=BLB0}
N 880 -830 940 -830 {lab=BLB0}
N 1150 -1060 1150 -810 {lab=BL1}
N 1150 -810 1230 -810 {lab=BL1}
N 1170 -1080 1170 -830 {lab=BLB1}
N 1170 -830 1230 -830 {lab=BLB1}
N 1440 -1060 1440 -810 {lab=BL2}
N 1440 -810 1520 -810 {lab=BL2}
N 1460 -1080 1460 -830 {lab=BLB2}
N 1460 -830 1520 -830 {lab=BLB2}
N 1730 -1060 1730 -810 {lab=BL3}
N 1730 -810 1810 -810 {lab=BL3}
N 1750 -1080 1750 -830 {lab=BLB3}
N 1750 -830 1810 -830 {lab=BLB3}
N 860 -810 860 -560 {lab=BL0}
N 860 -560 940 -560 {lab=BL0}
N 880 -830 880 -580 {lab=BLB0}
N 880 -580 940 -580 {lab=BLB0}
N 1150 -810 1150 -560 {lab=BL1}
N 1150 -560 1230 -560 {lab=BL1}
N 1170 -830 1170 -580 {lab=BLB1}
N 1170 -580 1230 -580 {lab=BLB1}
N 1440 -810 1440 -560 {lab=BL2}
N 1440 -560 1520 -560 {lab=BL2}
N 1460 -830 1460 -580 {lab=BLB2}
N 1460 -580 1520 -580 {lab=BLB2}
N 1730 -810 1730 -560 {lab=BL3}
N 1730 -560 1810 -560 {lab=BL3}
N 1750 -830 1750 -580 {lab=BLB3}
N 1750 -580 1810 -580 {lab=BLB3}
N 860 -560 860 -310 {lab=BL0}
N 860 -310 940 -310 {lab=BL0}
N 880 -580 880 -330 {lab=BLB0}
N 880 -330 940 -330 {lab=BLB0}
N 1150 -560 1150 -310 {lab=BL1}
N 1150 -310 1230 -310 {lab=BL1}
N 1170 -580 1170 -330 {lab=BLB1}
N 1170 -330 1230 -330 {lab=BLB1}
N 1440 -560 1440 -310 {lab=BL2}
N 1440 -310 1520 -310 {lab=BL2}
N 1460 -580 1460 -330 {lab=BLB2}
N 1460 -330 1520 -330 {lab=BLB2}
N 1730 -560 1730 -310 {lab=BL3}
N 1730 -310 1810 -310 {lab=BL3}
N 1750 -580 1750 -330 {lab=BLB3}
N 1750 -330 1810 -330 {lab=BLB3}
N 2040 -2190 2040 -2080 {lab=BLB4}
N 2040 -2080 2100 -2080 {lab=BLB4}
N 2020 -2240 2020 -2060 {lab=BL4}
N 2020 -2060 2100 -2060 {lab=BL4}
N 2330 -2190 2330 -2080 {lab=BLB5}
N 2330 -2080 2390 -2080 {lab=BLB5}
N 2310 -2240 2310 -2060 {lab=BL5}
N 2310 -2060 2390 -2060 {lab=BL5}
N 2620 -2190 2620 -2080 {lab=BLB6}
N 2620 -2080 2680 -2080 {lab=BLB6}
N 2600 -2240 2600 -2060 {lab=BL6}
N 2600 -2060 2680 -2060 {lab=BL6}
N 2910 -2190 2910 -2080 {lab=BLB7}
N 2910 -2080 2970 -2080 {lab=BLB7}
N 2890 -2240 2890 -2060 {lab=BL7}
N 2890 -2060 2970 -2060 {lab=BL7}
N 2020 -2060 2020 -1810 {lab=BL4}
N 2020 -1810 2100 -1810 {lab=BL4}
N 2040 -2080 2040 -1830 {lab=BLB4}
N 2040 -1830 2100 -1830 {lab=BLB4}
N 2310 -2060 2310 -1810 {lab=BL5}
N 2310 -1810 2390 -1810 {lab=BL5}
N 2330 -2080 2330 -1830 {lab=BLB5}
N 2330 -1830 2390 -1830 {lab=BLB5}
N 2600 -2060 2600 -1810 {lab=BL6}
N 2600 -1810 2680 -1810 {lab=BL6}
N 2620 -2080 2620 -1830 {lab=BLB6}
N 2620 -1830 2680 -1830 {lab=BLB6}
N 2890 -2060 2890 -1810 {lab=BL7}
N 2890 -1810 2970 -1810 {lab=BL7}
N 2910 -2080 2910 -1830 {lab=BLB7}
N 2910 -1830 2970 -1830 {lab=BLB7}
N 2020 -1810 2020 -1560 {lab=BL4}
N 2020 -1560 2100 -1560 {lab=BL4}
N 2040 -1830 2040 -1580 {lab=BLB4}
N 2040 -1580 2100 -1580 {lab=BLB4}
N 2310 -1810 2310 -1560 {lab=BL5}
N 2310 -1560 2390 -1560 {lab=BL5}
N 2330 -1830 2330 -1580 {lab=BLB5}
N 2330 -1580 2390 -1580 {lab=BLB5}
N 2600 -1810 2600 -1560 {lab=BL6}
N 2600 -1560 2680 -1560 {lab=BL6}
N 2620 -1830 2620 -1580 {lab=BLB6}
N 2620 -1580 2680 -1580 {lab=BLB6}
N 2890 -1810 2890 -1560 {lab=BL7}
N 2890 -1560 2970 -1560 {lab=BL7}
N 2910 -1830 2910 -1580 {lab=BLB7}
N 2910 -1580 2970 -1580 {lab=BLB7}
N 2020 -1560 2020 -1310 {lab=BL4}
N 2020 -1310 2100 -1310 {lab=BL4}
N 2040 -1580 2040 -1330 {lab=BLB4}
N 2040 -1330 2100 -1330 {lab=BLB4}
N 2310 -1560 2310 -1310 {lab=BL5}
N 2310 -1310 2390 -1310 {lab=BL5}
N 2330 -1580 2330 -1330 {lab=BLB5}
N 2330 -1330 2390 -1330 {lab=BLB5}
N 2600 -1560 2600 -1310 {lab=BL6}
N 2600 -1310 2680 -1310 {lab=BL6}
N 2620 -1580 2620 -1330 {lab=BLB6}
N 2620 -1330 2680 -1330 {lab=BLB6}
N 2890 -1560 2890 -1310 {lab=BL7}
N 2890 -1310 2970 -1310 {lab=BL7}
N 2910 -1580 2910 -1330 {lab=BLB7}
N 2910 -1330 2970 -1330 {lab=BLB7}
N 2020 -1310 2020 -1060 {lab=BL4}
N 2020 -1060 2100 -1060 {lab=BL4}
N 2040 -1330 2040 -1080 {lab=BLB4}
N 2040 -1080 2100 -1080 {lab=BLB4}
N 2310 -1310 2310 -1060 {lab=BL5}
N 2310 -1060 2390 -1060 {lab=BL5}
N 2330 -1330 2330 -1080 {lab=BLB5}
N 2330 -1080 2390 -1080 {lab=BLB5}
N 2600 -1310 2600 -1060 {lab=BL6}
N 2600 -1060 2680 -1060 {lab=BL6}
N 2620 -1330 2620 -1080 {lab=BLB6}
N 2620 -1080 2680 -1080 {lab=BLB6}
N 2890 -1310 2890 -1060 {lab=BL7}
N 2890 -1060 2970 -1060 {lab=BL7}
N 2910 -1330 2910 -1080 {lab=BLB7}
N 2910 -1080 2970 -1080 {lab=BLB7}
N 2020 -1060 2020 -810 {lab=BL4}
N 2020 -810 2100 -810 {lab=BL4}
N 2040 -1080 2040 -830 {lab=BLB4}
N 2040 -830 2100 -830 {lab=BLB4}
N 2310 -1060 2310 -810 {lab=BL5}
N 2310 -810 2390 -810 {lab=BL5}
N 2330 -1080 2330 -830 {lab=BLB5}
N 2330 -830 2390 -830 {lab=BLB5}
N 2600 -1060 2600 -810 {lab=BL6}
N 2600 -810 2680 -810 {lab=BL6}
N 2620 -1080 2620 -830 {lab=BLB6}
N 2620 -830 2680 -830 {lab=BLB6}
N 2890 -1060 2890 -810 {lab=BL7}
N 2890 -810 2970 -810 {lab=BL7}
N 2910 -1080 2910 -830 {lab=BLB7}
N 2910 -830 2970 -830 {lab=BLB7}
N 2020 -810 2020 -560 {lab=BL4}
N 2020 -560 2100 -560 {lab=BL4}
N 2040 -830 2040 -580 {lab=BLB4}
N 2040 -580 2100 -580 {lab=BLB4}
N 2310 -810 2310 -560 {lab=BL5}
N 2310 -560 2390 -560 {lab=BL5}
N 2330 -830 2330 -580 {lab=BLB5}
N 2330 -580 2390 -580 {lab=BLB5}
N 2600 -810 2600 -560 {lab=BL6}
N 2600 -560 2680 -560 {lab=BL6}
N 2620 -830 2620 -580 {lab=BLB6}
N 2620 -580 2680 -580 {lab=BLB6}
N 2890 -810 2890 -560 {lab=BL7}
N 2890 -560 2970 -560 {lab=BL7}
N 2910 -830 2910 -580 {lab=BLB7}
N 2910 -580 2970 -580 {lab=BLB7}
N 2020 -560 2020 -310 {lab=BL4}
N 2020 -310 2100 -310 {lab=BL4}
N 2040 -580 2040 -330 {lab=BLB4}
N 2040 -330 2100 -330 {lab=BLB4}
N 2310 -560 2310 -310 {lab=BL5}
N 2310 -310 2390 -310 {lab=BL5}
N 2330 -580 2330 -330 {lab=BLB5}
N 2330 -330 2390 -330 {lab=BLB5}
N 2600 -560 2600 -310 {lab=BL6}
N 2600 -310 2680 -310 {lab=BL6}
N 2620 -580 2620 -330 {lab=BLB6}
N 2620 -330 2680 -330 {lab=BLB6}
N 2890 -560 2890 -310 {lab=BL7}
N 2890 -310 2970 -310 {lab=BL7}
N 2910 -580 2910 -330 {lab=BLB7}
N 2910 -330 2970 -330 {lab=BLB7}
N 730 -2140 730 -200 {lab=WL[0..7]}
N 1980 320 2060 320 {lab=MACC4}
N 2000 300 2060 300 {lab=MAC2_barC4}
N 2270 320 2350 320 {lab=MACC5}
N 2290 300 2350 300 {lab=MAC2_barC5}
N 2560 320 2640 320 {lab=MACC6}
N 2580 300 2640 300 {lab=MAC2_barC6}
N 2850 320 2930 320 {lab=MACC7}
N 2870 300 2930 300 {lab=MAC2_barC7}
N 2000 50 2000 300 {lab=MAC2_barC4}
N 2290 50 2290 300 {lab=MAC2_barC5}
N 2580 50 2580 300 {lab=MAC2_barC6}
N 2870 50 2870 300 {lab=MAC2_barC7}
N 1980 210 1980 320 {lab=MACC4}
N 2270 210 2270 320 {lab=MACC5}
N 2560 210 2560 320 {lab=MACC6}
N 2850 210 2850 320 {lab=MACC7}
N 2100 -3210 2100 -3120 {lab=RBL4}
N 2100 -3150 2150 -3150 {lab=RBL4}
N 2100 -3290 2100 -3270 {lab=GND}
N 2100 -3240 2110 -3240 {lab=GND}
N 2110 -3280 2110 -3240 {lab=GND}
N 2100 -3280 2110 -3280 {lab=GND}
N 2040 -3240 2060 -3240 {lab=PRE}
N 2390 -3210 2390 -3120 {lab=RBL5}
N 2390 -3150 2440 -3150 {lab=RBL5}
N 2390 -3290 2390 -3270 {lab=GND}
N 2390 -3240 2400 -3240 {lab=GND}
N 2400 -3280 2400 -3240 {lab=GND}
N 2390 -3280 2400 -3280 {lab=GND}
N 2330 -3240 2350 -3240 {lab=PRE}
N 2680 -3210 2680 -3120 {lab=RBL6}
N 2680 -3150 2730 -3150 {lab=RBL6}
N 2680 -3290 2680 -3270 {lab=GND}
N 2680 -3240 2690 -3240 {lab=GND}
N 2690 -3280 2690 -3240 {lab=GND}
N 2680 -3280 2690 -3280 {lab=GND}
N 2620 -3240 2640 -3240 {lab=PRE}
N 2970 -3210 2970 -3120 {lab=RBL7}
N 2970 -3290 2970 -3270 {lab=GND}
N 2970 -3240 2980 -3240 {lab=GND}
N 2980 -3280 2980 -3240 {lab=GND}
N 2970 -3280 2980 -3280 {lab=GND}
N 2910 -3240 2930 -3240 {lab=PRE}
N 2970 -3150 3020 -3150 {lab=RBL7}
N 970 -2730 3090 -2730 {lab=MACC[0..7]
bus=true}
N 1020 -2720 1020 -2470 {lab=MACC0}
N 1310 -2720 1310 -2470 {lab=MACC1}
N 1600 -2720 1600 -2470 {lab=MACC2}
N 1890 -2720 1890 -2470 {lab=MACC3}
N 2180 -2720 2180 -2470 {lab=MACC4}
N 2470 -2720 2470 -2470 {lab=MACC5}
N 2760 -2720 2760 -2470 {lab=MACC6}
N 3050 -2720 3050 -2470 {lab=MACC7}
C {iopin.sym} 110 -2040 0 0 {name=p7 lab=WL[0..7]}
C {lab_pin.sym} 110 -2040 0 0 {name=p18 sig_type=std_logic lab=WL[0..7]}
C {lab_pin.sym} 940 -2100 0 0 {name=p1 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 940 -2000 0 0 {name=p43 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -2120 0 0 {name=p51 sig_type=std_logic lab=VCC}
C {code.sym} -1330 -1760 0 0 {
name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
spice_ignore=false
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
"
spice_ignore=false
      }
C {code_shown.sym} -1200 -1890 0 0 {name=s2 only_toplevel=false spice_ignore=false value=
"
.param VCC=1.8 VSS=0

V_VCC VCC 0 DC 1.8
V_VSS VSS 0 DC 0
"}
C {iopin.sym} 110 -1950 0 0 {name=p69 lab=S2}
C {iopin.sym} 110 -1930 0 0 {name=p70 lab=S1}
C {iopin.sym} 110 -1910 0 0 {name=p71 lab=S0}
C {lab_pin.sym} 110 -1950 0 0 {name=p72 sig_type=std_logic lab=S2}
C {lab_pin.sym} 110 -1930 0 0 {name=p73 sig_type=std_logic lab=S1}
C {lab_pin.sym} 110 -1910 0 0 {name=p74 sig_type=std_logic lab=S0}
C {iopin.sym} 110 -2310 0 0 {name=p78 lab=VCC}
C {iopin.sym} 110 -2290 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 110 -2290 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 110 -2310 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -2150 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 110 -2150 0 0 {name=p83 sig_type=std_logic lab=EN}
C {code_shown.sym} -480 -1590 0 1 {name=s3 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=8 pre_time=6ns read_time=2ns write_delay=10ns 


*V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
V_BLB0 BL0 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL1 BLB1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
V_BLB1 BL1 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})

V_BL2 BLB2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})
V_BLB2 BL2 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

V_BL3 BLB3 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})
V_BLB3 BL3 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*8\} \{BL_period*16\} \{prds\})

V_BL4 BLB4 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})
V_BLB4 BL4 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*16\} \{BL_period*32\} \{prds\})

V_BL5 BLB5 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})
V_BLB5 BL5 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*32\} \{BL_period*64\} \{prds\})

V_BL6 BLB6 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})
V_BLB6 BL6 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*64\} \{BL_period*128\} \{prds\})

V_BL7 BLB7 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})
V_BLB7 BL7 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period*128\} \{BL_period*256\} \{prds\})



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds*2\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds*2\})

.tran 0.01ns \{BL_period*2*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {lab_pin.sym} 940 -2020 0 0 {name=p87 sig_type=std_logic lab=RWL}
C {iopin.sym} 110 -1880 0 0 {name=p89 lab=RBL[0..7]}
C {iopin.sym} 110 -1860 0 0 {name=p90 lab=RWL}
C {lab_pin.sym} 110 -1880 0 0 {name=p91 sig_type=std_logic lab=RBL[0..7]}
C {lab_pin.sym} 110 -1860 0 0 {name=p92 sig_type=std_logic lab=RWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 940 -3090 0 0 {name=C2 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 940 -3290 2 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 920 -3240 2 1 {name=M2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 940 -3060 0 1 {name=l10 lab=GND}
C {iopin.sym} 110 -1840 0 0 {name=p93 lab=PRE}
C {lab_pin.sym} 110 -1840 0 0 {name=p95 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 880 -3240 0 0 {name=p96 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 1230 -2100 0 0 {name=p2 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1230 -2000 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1230 -2120 0 0 {name=p6 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1090 -2060 0 1 {name=x1}
C {lab_pin.sym} 1230 -2020 0 0 {name=p15 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -2100 0 0 {name=p28 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1520 -2000 0 0 {name=p31 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1520 -2120 0 0 {name=p32 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1380 -2060 0 1 {name=x2}
C {lab_pin.sym} 1520 -2020 0 0 {name=p33 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -2100 0 0 {name=p36 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 1810 -2000 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1810 -2120 0 0 {name=p40 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 1670 -2060 0 1 {name=x3}
C {lab_pin.sym} 1810 -2020 0 0 {name=p41 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -2060 0 1 {name=x4}
C {lab_pin.sym} 1810 -2040 0 0 {name=p52 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -2040 0 0 {name=p88 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -2040 0 0 {name=p105 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -2040 0 0 {name=p112 sig_type=std_logic lab=RBL0}
C {iopin.sym} 110 -2010 0 0 {name=p17 lab=BL[0..7]}
C {lab_pin.sym} 110 -2010 0 0 {name=p26 sig_type=std_logic lab=BL[0..7]}
C {iopin.sym} 110 -1990 0 0 {name=p59 lab=BLB[0..7]}
C {lab_pin.sym} 110 -1990 0 0 {name=p60 sig_type=std_logic lab=BLB[0..7]}
C {logic gates/decoder.sym} 100 -1570 0 0 {name=x77}
C {lab_pin.sym} 40 -1590 0 0 {name=p75 sig_type=std_logic lab=S2}
C {lab_pin.sym} 40 -1570 0 0 {name=p76 sig_type=std_logic lab=S1}
C {lab_pin.sym} 40 -1550 0 0 {name=p77 sig_type=std_logic lab=S0}
C {lab_pin.sym} 40 -1520 0 0 {name=p84 sig_type=std_logic lab=EN}
C {lab_pin.sym} 100 -1660 0 0 {name=p85 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -1480 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {bus_tap.sym} 850 -2250 1 0 {name=l2 lab=0}
C {lab_pin.sym} 850 -2250 0 0 {name=p3 sig_type=std_logic lab=BL[0..7]}
C {lab_pin.sym} 850 -2200 0 0 {name=p4 sig_type=std_logic lab=BLB[0..7]}
C {bus_tap.sym} 870 -2200 1 0 {name=l3 lab=0}
C {bus_tap.sym} 1140 -2250 1 0 {name=l4 lab=1}
C {bus_tap.sym} 1160 -2200 1 0 {name=l5 lab=1}
C {bus_tap.sym} 1430 -2250 1 0 {name=l6 lab=2}
C {bus_tap.sym} 1450 -2200 1 0 {name=l7 lab=2}
C {bus_tap.sym} 1720 -2250 1 0 {name=l8 lab=3}
C {bus_tap.sym} 1740 -2200 1 0 {name=l9 lab=3}
C {code_shown.sym} -1440 -1590 0 1 {name=s4 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {lab_pin.sym} 200 -1670 0 1 {name=p8 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 200 -1590 3 1 {name=l21 lab=4}
C {bus_tap.sym} 200 -1570 3 1 {name=l22 lab=3}
C {bus_tap.sym} 200 -1550 3 1 {name=l23 lab=2}
C {bus_tap.sym} 200 -1510 3 1 {name=l24 lab=0}
C {bus_tap.sym} 200 -1530 3 1 {name=l25 lab=1}
C {bus_tap.sym} 200 -1610 3 1 {name=l19 lab=5}
C {bus_tap.sym} 200 -1630 3 1 {name=l20 lab=6}
C {bus_tap.sym} 200 -1650 3 1 {name=l26 lab=7}
C {lab_pin.sym} 940 -1750 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1770 0 0 {name=p10 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1750 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1810 0 1 {name=x10}
C {lab_pin.sym} 1230 -1770 0 0 {name=p13 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1750 0 0 {name=p19 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1810 0 1 {name=x11}
C {lab_pin.sym} 1520 -1770 0 0 {name=p20 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1750 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1810 0 1 {name=x12}
C {lab_pin.sym} 1810 -1770 0 0 {name=p23 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -1810 0 1 {name=x13}
C {lab_pin.sym} 940 -1870 0 0 {name=p62 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1870 0 0 {name=p63 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1870 0 0 {name=p64 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1870 0 0 {name=p65 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1850 0 0 {name=p107 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1230 -1850 0 0 {name=p108 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1520 -1850 0 0 {name=p113 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 1810 -1850 0 0 {name=p114 sig_type=std_logic lab=WL1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1230 -3090 0 0 {name=C1 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1230 -3290 2 0 {name=l27 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1210 -3240 2 1 {name=M1
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1230 -3060 0 1 {name=l28 lab=GND}
C {lab_pin.sym} 1170 -3240 0 0 {name=p99 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1520 -3090 0 0 {name=C3 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1520 -3290 2 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1500 -3240 2 1 {name=M3
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1520 -3060 0 1 {name=l30 lab=GND}
C {lab_pin.sym} 1460 -3240 0 0 {name=p119 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1810 -3090 0 0 {name=C4 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 1810 -3290 2 0 {name=l31 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -3240 2 1 {name=M4
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1810 -3060 0 1 {name=l32 lab=GND}
C {lab_pin.sym} 1750 -3240 0 0 {name=p121 sig_type=std_logic lab=PRE}
C {iopin.sym} 110 -2100 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 110 -2100 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 110 -2080 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 110 -2080 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 110 -2130 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 110 -2130 0 0 {name=p136 lab=EN_bar}
C {lab_pin.sym} 110 -1810 0 0 {name=p145 sig_type=std_logic lab=TR[0..7]}
C {iopin.sym} 110 -1810 0 0 {name=p146 lab=TR[0..7]}
C {lab_pin.sym} 1810 -1790 0 0 {name=p29 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -1790 0 0 {name=p37 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -1790 0 0 {name=p46 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -1790 0 0 {name=p50 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 1860 -3150 0 1 {name=p122 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1570 -3150 0 1 {name=p124 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1280 -3150 0 1 {name=p126 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 990 -3150 0 1 {name=p128 sig_type=std_logic lab=RBL0}
C {voltage_comp/MAC_decoder_7.sym} 1130 -2890 0 0 {name=x18}
C {lab_pin.sym} 990 -2950 0 1 {name=p139 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 990 -2970 0 1 {name=p140 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 990 -2930 0 1 {name=p141 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 990 -2910 0 1 {name=p142 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 990 -2850 0 1 {name=p143 sig_type=std_logic lab=MACC0}
C {lab_pin.sym} 990 -2870 0 1 {name=p144 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 840 -2890 0 0 {name=x17}
C {lab_pin.sym} 1280 -2950 0 1 {name=p150 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1280 -2970 0 1 {name=p151 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1280 -2930 0 1 {name=p152 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1280 -2910 0 1 {name=p153 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1280 -2850 0 1 {name=p154 sig_type=std_logic lab=MACC1}
C {lab_pin.sym} 1280 -2870 0 1 {name=p155 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 1420 -2890 0 0 {name=x19}
C {lab_pin.sym} 1570 -2950 0 1 {name=p159 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1570 -2970 0 1 {name=p160 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1570 -2930 0 1 {name=p161 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1570 -2910 0 1 {name=p162 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1570 -2850 0 1 {name=p163 sig_type=std_logic lab=MACC2}
C {lab_pin.sym} 1570 -2870 0 1 {name=p164 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 1710 -2890 0 0 {name=x20}
C {lab_pin.sym} 1860 -2950 0 1 {name=p168 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1860 -2970 0 1 {name=p169 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1860 -2930 0 1 {name=p170 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 1860 -2910 0 1 {name=p171 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1860 -2850 0 1 {name=p172 sig_type=std_logic lab=MACC3}
C {lab_pin.sym} 1860 -2870 0 1 {name=p173 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 1860 -2890 0 1 {name=p174 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1570 -2890 0 1 {name=p183 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1280 -2890 0 1 {name=p192 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 990 -2890 0 1 {name=p201 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 110 -1790 0 0 {name=p210 sig_type=std_logic lab=MAC[0..7]}
C {iopin.sym} 110 -1790 0 0 {name=p211 lab=MAC[0..7]}
C {iopin.sym} 110 -1770 0 0 {name=p212 lab=MACRBL}
C {lab_pin.sym} 110 -1770 0 0 {name=p213 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 900 380 0 0 {name=p214 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 900 360 0 0 {name=p215 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1190 380 0 0 {name=p216 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1050 320 0 1 {name=x26}
C {lab_pin.sym} 1190 360 0 0 {name=p217 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1480 380 0 0 {name=p218 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1340 320 0 1 {name=x27}
C {lab_pin.sym} 1480 360 0 0 {name=p219 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 1770 380 0 0 {name=p220 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1630 320 0 1 {name=x28}
C {lab_pin.sym} 1770 360 0 0 {name=p221 sig_type=std_logic lab=MACRWL}
C {8T_sram_cell_c.sym} 1920 320 0 1 {name=x29}
C {lab_pin.sym} 900 260 0 0 {name=p230 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1190 260 0 0 {name=p231 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1480 260 0 0 {name=p232 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1770 260 0 0 {name=p233 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 900 280 0 0 {name=p238 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1190 280 0 0 {name=p239 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1480 280 0 0 {name=p240 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1770 280 0 0 {name=p241 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 1770 340 0 0 {name=p250 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1480 340 0 0 {name=p251 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 1190 340 0 0 {name=p252 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 900 340 0 0 {name=p253 sig_type=std_logic lab=MACRBL}
C {iopin.sym} 110 -1750 0 0 {name=p254 lab=MACRWL}
C {lab_pin.sym} 110 -1750 0 0 {name=p255 sig_type=std_logic lab=MACRWL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3530 -1390 0 0 {name=C9 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 3530 -1590 2 0 {name=l41 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3510 -1540 2 1 {name=M9
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 3530 -1360 0 1 {name=l42 lab=GND}
C {lab_pin.sym} 3470 -1540 0 0 {name=p256 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 3580 -1450 0 1 {name=p257 sig_type=std_logic lab=MACRBL}
C {bus_tap.sym} 830 40 1 0 {name=l51 lab=0}
C {bus_tap.sym} 1120 40 1 0 {name=l52 lab=1}
C {bus_tap.sym} 1410 40 1 0 {name=l53 lab=2}
C {bus_tap.sym} 1700 40 1 0 {name=l54 lab=3}
C {bus_tap.sym} 810 200 1 0 {name=l59 lab=0}
C {bus_tap.sym} 1100 200 1 0 {name=l60 lab=1}
C {bus_tap.sym} 1390 200 1 0 {name=l61 lab=2}
C {bus_tap.sym} 1680 200 1 0 {name=l62 lab=3}
C {lab_pin.sym} 670 40 0 0 {name=p277 sig_type=std_logic lab=MACC[0..7]}
C {inv.sym} 730 40 0 0 {name=x34[0..7]}
C {lab_pin.sym} 730 20 0 1 {name=p278 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 730 60 0 1 {name=p279 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 810 -60 2 1 {name=p280 sig_type=std_logic lab=MAC2_barC[0..7]}
C {code_shown.sym} -2470 -1590 0 1 {name=s1 only_toplevel=false spice_ignore=true value=
"
.param dly=0ns t_dly=1ns rise=10ps fall=10ps BL_period=20ns prds=10 pre_time=6ns read_time=2ns write_delay=10ns 


V_S0 S0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_S1 S1 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*2\} \{BL_period*4\} \{prds\})
*V_S2 S2 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period*4\} \{BL_period*8\} \{prds\})

*V_S0 S0 0 DC 1.8
V_S1 S1 0 DC 1.8
V_S2 S2 0 DC 1.8

*V_EN EN 0 DC 1.8
V_EN EN 0 PULSE(\{VSS\} \{VCC\} \{dly+t_dly\} \{rise\} \{fall\} \{(BL_period/2)-t_dly*2\} \{BL_period\} \{prds\})

*V_IN0 IN0 0 DC 1
*V_IN0_bar IN0_bar 0 DC 0
*V_IN0 IN0 0 PWL(0ns 1.8 9.99ns 1.8 10ns 0 20ns 0 30ns 0 40ns 0 50ns 0 60ns 0 69.99ns 0 70ns 1.8)
*V_IN0_bar IN0_bar 0 PWL(0ns 0 9.99ns 0 10ns 1.8 20ns 1.8 30ns 1.8 40ns 1.8 50ns 1.8 60ns 1.8 69.99ns 1.8 70ns 0)
*V_IN0 IN0 0 PULSE(\{VSS\} \{VCC\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})
*V_IN0_bar IN0_bar 0 PULSE(\{VCC\} \{VSS\} \{dly\} \{rise\} \{fall\} \{BL_period\} \{BL_period*2\} \{prds\})

V_BL0 BLB0 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB0 BL0 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL1 BLB1 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB1 BL1 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL2 BLB2 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB2 BL2 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL3 BLB3 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB3 BL3 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL4 BLB4 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB4 BL4 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL5 BLB5 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB5 BL5 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL6 BLB6 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB6 BL6 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)

V_BL7 BLB7 0 PWL(0ns 1.8 20ns 1.8 40ns 1.8 59.99ns 1.8 60ns 0 80ns 0 99.99ns 0 100ns 1.8 119.99ns 1.8 120ns 0 140ns 0)
V_BLB7 BL7 0 PWL(0ns 0 20ns 0 40ns 0 59.99ns 0 60ns 1.8 80ns 1.8 99.99ns 1.8 100ns 0 119.99ns 0 120ns 1.8 140ns 1.8)



*V_RWL RWL 0 DC 1.8
*V_RBL RBL 0 DC 0
*V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{write_delay+t_dly+pre_time+t_dly\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
*V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{write_delay+t_dly\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})
V_RWL RWL 0 PULSE(\{VCC\} \{VSS\} \{dly + BL_period/2 + 7ns\} \{rise\} \{fall\} \{read_time\} \{BL_period\} \{prds\})
V_PRE PRE 0 PULSE(\{VSS\} \{VCC\} \{dly + BL_period/2\} \{rise\} \{fall\} \{pre_time\} \{BL_period\} \{prds\})

.tran 0.01ns \{BL_period*10\}
.save all

.control
run
plot Y0 Y1+2 Y2+4 Y3+6 Y4+8 Y5+10 Y6+12 Y7+14
plot EN
plot I0 I1+2 I2+4
.endc
"}
C {iopin.sym} 110 -2200 0 0 {name=p281 lab=MAC_EN}
C {lab_pin.sym} 110 -2200 0 0 {name=p282 sig_type=std_logic lab=MAC_EN}
C {iopin.sym} 110 -2180 0 0 {name=p283 lab=MAC_EN_bar}
C {lab_pin.sym} 110 -2180 0 0 {name=p284 lab=MAC_EN_bar}
C {lab_pin.sym} 990 -2810 0 1 {name=p285 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 990 -2830 0 1 {name=p286 lab=MAC_EN}
C {lab_pin.sym} 1280 -2810 0 1 {name=p287 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1280 -2830 0 1 {name=p288 lab=MAC_EN}
C {lab_pin.sym} 1570 -2810 0 1 {name=p289 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1570 -2830 0 1 {name=p290 lab=MAC_EN}
C {lab_pin.sym} 1860 -2810 0 1 {name=p291 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 1860 -2830 0 1 {name=p292 lab=MAC_EN}
C {code_shown.sym} -1200 -1750 0 0 {name=s5 only_toplevel=false value=
"
.param VSS=0 VCC=1.8 BL_period=3ns t_dly=1ns rise=10ps fall =10ps rwl_time=0.5ns pre_time=6ns clk_period=30ns

.include "/home/user/pyvenvs/sky130venv/spice_files/ham_code.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/thresholds.spice"
.save all

"}
C {lab_pin.sym} 680 200 0 0 {name=p137 sig_type=std_logic lab=MACC[0..7]}
C {code_shown.sym} -980 -1890 0 0 {name=s6 only_toplevel=false spice_ignore=false value=
"
*.include "/home/user/pyvenvs/sky130venv/nodeset.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/set_sram_ham_small.spice"
"}
C {lab_pin.sym} 940 -1500 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1520 0 0 {name=p14 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1500 0 0 {name=p16 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1560 0 1 {name=x5}
C {lab_pin.sym} 1230 -1520 0 0 {name=p21 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1500 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1560 0 1 {name=x6}
C {lab_pin.sym} 1520 -1520 0 0 {name=p25 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1500 0 0 {name=p27 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1560 0 1 {name=x7}
C {lab_pin.sym} 1810 -1520 0 0 {name=p30 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -1560 0 1 {name=x8}
C {lab_pin.sym} 940 -1620 0 0 {name=p34 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1620 0 0 {name=p35 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1620 0 0 {name=p38 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1620 0 0 {name=p42 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1600 0 0 {name=p44 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1230 -1600 0 0 {name=p45 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1520 -1600 0 0 {name=p47 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1810 -1600 0 0 {name=p48 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 1810 -1540 0 0 {name=p49 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -1540 0 0 {name=p53 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -1540 0 0 {name=p54 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -1540 0 0 {name=p55 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1250 0 0 {name=p56 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1270 0 0 {name=p57 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1250 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1310 0 1 {name=x9}
C {lab_pin.sym} 1230 -1270 0 0 {name=p61 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1250 0 0 {name=p66 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1310 0 1 {name=x14}
C {lab_pin.sym} 1520 -1270 0 0 {name=p67 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1250 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1310 0 1 {name=x15}
C {lab_pin.sym} 1810 -1270 0 0 {name=p94 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -1310 0 1 {name=x16}
C {lab_pin.sym} 940 -1370 0 0 {name=p97 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1370 0 0 {name=p98 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1370 0 0 {name=p100 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1370 0 0 {name=p101 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1350 0 0 {name=p102 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1230 -1350 0 0 {name=p103 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1520 -1350 0 0 {name=p104 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1810 -1350 0 0 {name=p106 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 1810 -1290 0 0 {name=p109 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -1290 0 0 {name=p110 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -1290 0 0 {name=p111 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -1290 0 0 {name=p115 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1000 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1020 0 0 {name=p117 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -1000 0 0 {name=p118 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -1060 0 1 {name=x21}
C {lab_pin.sym} 1230 -1020 0 0 {name=p120 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -1000 0 0 {name=p123 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -1060 0 1 {name=x22}
C {lab_pin.sym} 1520 -1020 0 0 {name=p125 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -1000 0 0 {name=p127 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -1060 0 1 {name=x23}
C {lab_pin.sym} 1810 -1020 0 0 {name=p129 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -1060 0 1 {name=x24}
C {lab_pin.sym} 940 -1120 0 0 {name=p130 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -1120 0 0 {name=p138 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -1120 0 0 {name=p147 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -1120 0 0 {name=p148 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1100 0 0 {name=p149 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1230 -1100 0 0 {name=p156 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1520 -1100 0 0 {name=p157 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1810 -1100 0 0 {name=p158 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 1810 -1040 0 0 {name=p165 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -1040 0 0 {name=p166 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -1040 0 0 {name=p167 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -1040 0 0 {name=p175 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -750 0 0 {name=p176 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -770 0 0 {name=p177 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -750 0 0 {name=p178 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -810 0 1 {name=x25}
C {lab_pin.sym} 1230 -770 0 0 {name=p179 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -750 0 0 {name=p180 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -810 0 1 {name=x30}
C {lab_pin.sym} 1520 -770 0 0 {name=p181 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -750 0 0 {name=p182 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -810 0 1 {name=x31}
C {lab_pin.sym} 1810 -770 0 0 {name=p184 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -810 0 1 {name=x32}
C {lab_pin.sym} 940 -870 0 0 {name=p185 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -870 0 0 {name=p186 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -870 0 0 {name=p187 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -870 0 0 {name=p188 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -850 0 0 {name=p189 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1230 -850 0 0 {name=p190 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1520 -850 0 0 {name=p191 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1810 -850 0 0 {name=p193 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 1810 -790 0 0 {name=p194 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -790 0 0 {name=p195 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -790 0 0 {name=p196 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -790 0 0 {name=p197 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -500 0 0 {name=p198 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -520 0 0 {name=p199 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -500 0 0 {name=p200 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -560 0 1 {name=x33}
C {lab_pin.sym} 1230 -520 0 0 {name=p202 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -500 0 0 {name=p203 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -560 0 1 {name=x34}
C {lab_pin.sym} 1520 -520 0 0 {name=p204 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -500 0 0 {name=p205 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -560 0 1 {name=x35}
C {lab_pin.sym} 1810 -520 0 0 {name=p206 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -560 0 1 {name=x36}
C {lab_pin.sym} 940 -620 0 0 {name=p207 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -620 0 0 {name=p208 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -620 0 0 {name=p209 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -620 0 0 {name=p222 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -600 0 0 {name=p223 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1230 -600 0 0 {name=p224 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1520 -600 0 0 {name=p225 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1810 -600 0 0 {name=p226 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 1810 -540 0 0 {name=p227 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -540 0 0 {name=p228 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -540 0 0 {name=p229 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -540 0 0 {name=p234 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -250 0 0 {name=p235 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -270 0 0 {name=p236 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1230 -250 0 0 {name=p237 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1090 -310 0 1 {name=x37}
C {lab_pin.sym} 1230 -270 0 0 {name=p242 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1520 -250 0 0 {name=p243 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1380 -310 0 1 {name=x38}
C {lab_pin.sym} 1520 -270 0 0 {name=p244 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 1810 -250 0 0 {name=p245 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 1670 -310 0 1 {name=x39}
C {lab_pin.sym} 1810 -270 0 0 {name=p246 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1960 -310 0 1 {name=x40}
C {lab_pin.sym} 940 -370 0 0 {name=p247 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1230 -370 0 0 {name=p248 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1520 -370 0 0 {name=p249 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1810 -370 0 0 {name=p258 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -350 0 0 {name=p259 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1230 -350 0 0 {name=p260 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1520 -350 0 0 {name=p261 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1810 -350 0 0 {name=p262 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 1810 -290 0 0 {name=p263 sig_type=std_logic lab=RBL3}
C {lab_pin.sym} 1520 -290 0 0 {name=p264 sig_type=std_logic lab=RBL2}
C {lab_pin.sym} 1230 -290 0 0 {name=p265 sig_type=std_logic lab=RBL1}
C {lab_pin.sym} 940 -290 0 0 {name=p266 sig_type=std_logic lab=RBL0}
C {8T_sram_cell_c.sym} 2250 -2060 0 1 {name=x41}
C {lab_pin.sym} 2970 -2040 0 0 {name=p267 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -2040 0 0 {name=p268 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -2040 0 0 {name=p269 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -2040 0 0 {name=p270 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2100 -2100 0 0 {name=p271 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2100 -2000 0 0 {name=p272 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -2120 0 0 {name=p273 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -2020 0 0 {name=p274 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -2100 0 0 {name=p275 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2390 -2000 0 0 {name=p276 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2390 -2120 0 0 {name=p293 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2540 -2060 0 1 {name=x42}
C {lab_pin.sym} 2390 -2020 0 0 {name=p294 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -2100 0 0 {name=p295 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2680 -2000 0 0 {name=p296 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2680 -2120 0 0 {name=p297 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 2830 -2060 0 1 {name=x43}
C {lab_pin.sym} 2680 -2020 0 0 {name=p298 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -2100 0 0 {name=p299 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 2970 -2000 0 0 {name=p300 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2970 -2120 0 0 {name=p301 sig_type=std_logic lab=VCC}
C {8T_sram_cell_c.sym} 3120 -2060 0 1 {name=x44}
C {lab_pin.sym} 2970 -2020 0 0 {name=p302 sig_type=std_logic lab=RWL}
C {bus_tap.sym} 2300 -2250 1 0 {name=l11 lab=5}
C {bus_tap.sym} 2320 -2200 1 0 {name=l12 lab=5}
C {bus_tap.sym} 2590 -2250 1 0 {name=l13 lab=6}
C {bus_tap.sym} 2610 -2200 1 0 {name=l14 lab=6}
C {bus_tap.sym} 2880 -2250 1 0 {name=l15 lab=7}
C {bus_tap.sym} 2900 -2200 1 0 {name=l16 lab=7}
C {bus_tap.sym} 2010 -2250 1 0 {name=l17 lab=4}
C {bus_tap.sym} 2030 -2200 1 0 {name=l18 lab=4}
C {8T_sram_cell_c.sym} 2250 -1810 0 1 {name=x45}
C {lab_pin.sym} 2100 -1750 0 0 {name=p303 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -1770 0 0 {name=p304 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1750 0 0 {name=p305 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1810 0 1 {name=x46}
C {lab_pin.sym} 2390 -1770 0 0 {name=p306 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1750 0 0 {name=p307 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1810 0 1 {name=x47}
C {lab_pin.sym} 2680 -1770 0 0 {name=p308 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1750 0 0 {name=p309 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1810 0 1 {name=x48}
C {lab_pin.sym} 2970 -1770 0 0 {name=p310 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1870 0 0 {name=p311 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1870 0 0 {name=p312 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1870 0 0 {name=p313 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1870 0 0 {name=p314 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1850 0 0 {name=p315 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2390 -1850 0 0 {name=p316 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2680 -1850 0 0 {name=p317 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2970 -1850 0 0 {name=p318 sig_type=std_logic lab=WL1}
C {lab_pin.sym} 2970 -1790 0 0 {name=p319 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -1790 0 0 {name=p320 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -1790 0 0 {name=p321 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -1790 0 0 {name=p322 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -1560 0 1 {name=x49}
C {lab_pin.sym} 2100 -1500 0 0 {name=p323 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -1520 0 0 {name=p324 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1500 0 0 {name=p325 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1560 0 1 {name=x50}
C {lab_pin.sym} 2390 -1520 0 0 {name=p326 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1500 0 0 {name=p327 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1560 0 1 {name=x51}
C {lab_pin.sym} 2680 -1520 0 0 {name=p328 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1500 0 0 {name=p329 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1560 0 1 {name=x52}
C {lab_pin.sym} 2970 -1520 0 0 {name=p330 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1620 0 0 {name=p331 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1620 0 0 {name=p332 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1620 0 0 {name=p333 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1620 0 0 {name=p334 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1600 0 0 {name=p335 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2390 -1600 0 0 {name=p336 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2680 -1600 0 0 {name=p337 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2970 -1600 0 0 {name=p338 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 2970 -1540 0 0 {name=p339 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -1540 0 0 {name=p340 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -1540 0 0 {name=p341 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -1540 0 0 {name=p342 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -1310 0 1 {name=x53}
C {lab_pin.sym} 2100 -1250 0 0 {name=p343 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -1270 0 0 {name=p344 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1250 0 0 {name=p345 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1310 0 1 {name=x54}
C {lab_pin.sym} 2390 -1270 0 0 {name=p346 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1250 0 0 {name=p347 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1310 0 1 {name=x55}
C {lab_pin.sym} 2680 -1270 0 0 {name=p348 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1250 0 0 {name=p349 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1310 0 1 {name=x56}
C {lab_pin.sym} 2970 -1270 0 0 {name=p350 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1370 0 0 {name=p351 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1370 0 0 {name=p352 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1370 0 0 {name=p353 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1370 0 0 {name=p354 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1350 0 0 {name=p355 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2390 -1350 0 0 {name=p356 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2680 -1350 0 0 {name=p357 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2970 -1350 0 0 {name=p358 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 2970 -1290 0 0 {name=p359 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -1290 0 0 {name=p360 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -1290 0 0 {name=p361 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -1290 0 0 {name=p362 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -1060 0 1 {name=x57}
C {lab_pin.sym} 2100 -1000 0 0 {name=p363 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -1020 0 0 {name=p364 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -1000 0 0 {name=p365 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -1060 0 1 {name=x58}
C {lab_pin.sym} 2390 -1020 0 0 {name=p366 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -1000 0 0 {name=p367 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -1060 0 1 {name=x59}
C {lab_pin.sym} 2680 -1020 0 0 {name=p368 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -1000 0 0 {name=p369 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -1060 0 1 {name=x60}
C {lab_pin.sym} 2970 -1020 0 0 {name=p370 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -1120 0 0 {name=p371 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -1120 0 0 {name=p372 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -1120 0 0 {name=p373 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -1120 0 0 {name=p374 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -1100 0 0 {name=p375 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2390 -1100 0 0 {name=p376 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2680 -1100 0 0 {name=p377 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2970 -1100 0 0 {name=p378 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 2970 -1040 0 0 {name=p379 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -1040 0 0 {name=p380 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -1040 0 0 {name=p381 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -1040 0 0 {name=p382 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -810 0 1 {name=x61}
C {lab_pin.sym} 2100 -750 0 0 {name=p383 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -770 0 0 {name=p384 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -750 0 0 {name=p385 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -810 0 1 {name=x62}
C {lab_pin.sym} 2390 -770 0 0 {name=p386 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -750 0 0 {name=p387 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -810 0 1 {name=x63}
C {lab_pin.sym} 2680 -770 0 0 {name=p388 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -750 0 0 {name=p389 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -810 0 1 {name=x64}
C {lab_pin.sym} 2970 -770 0 0 {name=p390 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -870 0 0 {name=p391 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -870 0 0 {name=p392 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -870 0 0 {name=p393 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -870 0 0 {name=p394 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -850 0 0 {name=p395 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2390 -850 0 0 {name=p396 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2680 -850 0 0 {name=p397 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2970 -850 0 0 {name=p398 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 2970 -790 0 0 {name=p399 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -790 0 0 {name=p400 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -790 0 0 {name=p401 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -790 0 0 {name=p402 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -560 0 1 {name=x65}
C {lab_pin.sym} 2100 -500 0 0 {name=p403 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -520 0 0 {name=p404 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -500 0 0 {name=p405 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -560 0 1 {name=x66}
C {lab_pin.sym} 2390 -520 0 0 {name=p406 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -500 0 0 {name=p407 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -560 0 1 {name=x67}
C {lab_pin.sym} 2680 -520 0 0 {name=p408 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -500 0 0 {name=p409 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -560 0 1 {name=x68}
C {lab_pin.sym} 2970 -520 0 0 {name=p410 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -620 0 0 {name=p411 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -620 0 0 {name=p412 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -620 0 0 {name=p413 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -620 0 0 {name=p414 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -600 0 0 {name=p415 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2390 -600 0 0 {name=p416 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2680 -600 0 0 {name=p417 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2970 -600 0 0 {name=p418 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 2970 -540 0 0 {name=p419 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -540 0 0 {name=p420 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -540 0 0 {name=p421 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -540 0 0 {name=p422 sig_type=std_logic lab=RBL4}
C {8T_sram_cell_c.sym} 2250 -310 0 1 {name=x69}
C {lab_pin.sym} 2100 -250 0 0 {name=p423 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -270 0 0 {name=p424 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2390 -250 0 0 {name=p425 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2540 -310 0 1 {name=x70}
C {lab_pin.sym} 2390 -270 0 0 {name=p426 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2680 -250 0 0 {name=p427 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2830 -310 0 1 {name=x71}
C {lab_pin.sym} 2680 -270 0 0 {name=p428 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2970 -250 0 0 {name=p429 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 3120 -310 0 1 {name=x72}
C {lab_pin.sym} 2970 -270 0 0 {name=p430 sig_type=std_logic lab=RWL}
C {lab_pin.sym} 2100 -370 0 0 {name=p431 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2390 -370 0 0 {name=p432 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2680 -370 0 0 {name=p433 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2970 -370 0 0 {name=p434 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2100 -350 0 0 {name=p435 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2390 -350 0 0 {name=p436 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2680 -350 0 0 {name=p437 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2970 -350 0 0 {name=p438 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 2970 -290 0 0 {name=p439 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2680 -290 0 0 {name=p440 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2390 -290 0 0 {name=p441 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2100 -290 0 0 {name=p442 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 730 -2140 0 0 {name=p443 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 730 -360 1 0 {name=l33 lab=7}
C {lab_pin.sym} 2060 380 0 0 {name=p444 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2060 360 0 0 {name=p445 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2350 380 0 0 {name=p446 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2210 320 0 1 {name=x73}
C {lab_pin.sym} 2350 360 0 0 {name=p447 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2640 380 0 0 {name=p448 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2500 320 0 1 {name=x74}
C {lab_pin.sym} 2640 360 0 0 {name=p449 sig_type=std_logic lab=MACRWL}
C {lab_pin.sym} 2930 380 0 0 {name=p450 sig_type=std_logic lab=VSS}
C {8T_sram_cell_c.sym} 2790 320 0 1 {name=x75}
C {lab_pin.sym} 2930 360 0 0 {name=p451 sig_type=std_logic lab=MACRWL}
C {8T_sram_cell_c.sym} 3080 320 0 1 {name=x76}
C {lab_pin.sym} 2060 260 0 0 {name=p452 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2350 260 0 0 {name=p453 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2640 260 0 0 {name=p454 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2930 260 0 0 {name=p455 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2060 280 0 0 {name=p456 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2350 280 0 0 {name=p457 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2640 280 0 0 {name=p458 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2930 280 0 0 {name=p459 sig_type=std_logic lab=WL8}
C {lab_pin.sym} 2930 340 0 0 {name=p460 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2640 340 0 0 {name=p461 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2350 340 0 0 {name=p462 sig_type=std_logic lab=MACRBL}
C {lab_pin.sym} 2060 340 0 0 {name=p463 sig_type=std_logic lab=MACRBL}
C {bus_tap.sym} 1990 40 1 0 {name=l34 lab=4}
C {bus_tap.sym} 2280 40 1 0 {name=l35 lab=5}
C {bus_tap.sym} 2570 40 1 0 {name=l36 lab=6}
C {bus_tap.sym} 2860 40 1 0 {name=l37 lab=7}
C {bus_tap.sym} 1970 200 1 0 {name=l38 lab=4}
C {bus_tap.sym} 2260 200 1 0 {name=l39 lab=5}
C {bus_tap.sym} 2550 200 1 0 {name=l40 lab=6}
C {bus_tap.sym} 2840 200 1 0 {name=l43 lab=7}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2100 -3090 0 0 {name=C5 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2100 -3290 2 0 {name=l44 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2080 -3240 2 1 {name=M5
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2100 -3060 0 1 {name=l45 lab=GND}
C {lab_pin.sym} 2040 -3240 0 0 {name=p464 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2390 -3090 0 0 {name=C6 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2390 -3290 2 0 {name=l46 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -3240 2 1 {name=M6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2390 -3060 0 1 {name=l47 lab=GND}
C {lab_pin.sym} 2330 -3240 0 0 {name=p465 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2680 -3090 0 0 {name=C7 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2680 -3290 2 0 {name=l48 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2660 -3240 2 1 {name=M7
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2680 -3060 0 1 {name=l49 lab=GND}
C {lab_pin.sym} 2620 -3240 0 0 {name=p466 sig_type=std_logic lab=PRE}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2970 -3090 0 0 {name=C8 model=cap_mim_m3_1 W=30 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 2970 -3290 2 0 {name=l50 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2950 -3240 2 1 {name=M8
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2970 -3060 0 1 {name=l55 lab=GND}
C {lab_pin.sym} 2910 -3240 0 0 {name=p467 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 3020 -3150 0 1 {name=p468 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2730 -3150 0 1 {name=p469 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 2440 -3150 0 1 {name=p470 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2150 -3150 0 1 {name=p471 sig_type=std_logic lab=RBL4}
C {voltage_comp/MAC_decoder_7.sym} 2290 -2890 0 0 {name=x78}
C {lab_pin.sym} 2150 -2950 0 1 {name=p472 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2150 -2970 0 1 {name=p473 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2150 -2930 0 1 {name=p474 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2150 -2910 0 1 {name=p475 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2150 -2850 0 1 {name=p476 sig_type=std_logic lab=MACC4}
C {lab_pin.sym} 2150 -2870 0 1 {name=p477 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 2000 -2890 0 0 {name=x79}
C {lab_pin.sym} 2440 -2950 0 1 {name=p478 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2440 -2970 0 1 {name=p479 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2440 -2930 0 1 {name=p480 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2440 -2910 0 1 {name=p481 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2440 -2850 0 1 {name=p482 sig_type=std_logic lab=MACC5}
C {lab_pin.sym} 2440 -2870 0 1 {name=p483 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 2580 -2890 0 0 {name=x80}
C {lab_pin.sym} 2730 -2950 0 1 {name=p484 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2730 -2970 0 1 {name=p485 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 2730 -2930 0 1 {name=p486 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 2730 -2910 0 1 {name=p487 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 2730 -2850 0 1 {name=p488 sig_type=std_logic lab=MACC6}
C {lab_pin.sym} 2730 -2870 0 1 {name=p489 sig_type=std_logic lab=TR[7..6]}
C {voltage_comp/MAC_decoder_7.sym} 2870 -2890 0 0 {name=x81}
C {lab_pin.sym} 3020 -2950 0 1 {name=p490 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3020 -2970 0 1 {name=p491 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 3020 -2930 0 1 {name=p492 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 3020 -2910 0 1 {name=p493 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 3020 -2850 0 1 {name=p494 sig_type=std_logic lab=MACC7}
C {lab_pin.sym} 3020 -2870 0 1 {name=p495 sig_type=std_logic lab=TR[7..6]}
C {lab_pin.sym} 2730 -2890 0 1 {name=p496 sig_type=std_logic lab=RBL6}
C {lab_pin.sym} 3020 -2890 0 1 {name=p497 sig_type=std_logic lab=RBL7}
C {lab_pin.sym} 2440 -2890 0 1 {name=p498 sig_type=std_logic lab=RBL5}
C {lab_pin.sym} 2150 -2890 0 1 {name=p499 sig_type=std_logic lab=RBL4}
C {lab_pin.sym} 2150 -2810 0 1 {name=p500 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2150 -2830 0 1 {name=p501 lab=MAC_EN}
C {lab_pin.sym} 2440 -2810 0 1 {name=p502 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2440 -2830 0 1 {name=p503 lab=MAC_EN}
C {lab_pin.sym} 2730 -2810 0 1 {name=p504 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 2730 -2830 0 1 {name=p505 lab=MAC_EN}
C {lab_pin.sym} 3020 -2810 0 1 {name=p506 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 3020 -2830 0 1 {name=p507 lab=MAC_EN}
C {launcher.sym} -60 -2480 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/ham_real_full.raw tran"
}
C {bus_tap.sym} 1010 -2730 1 0 {name=l56 lab=0}
C {bus_tap.sym} 1300 -2730 1 0 {name=l57 lab=1}
C {bus_tap.sym} 1590 -2730 1 0 {name=l58 lab=2}
C {bus_tap.sym} 1880 -2730 1 0 {name=l63 lab=3}
C {lab_pin.sym} 970 -2730 0 0 {name=p508 sig_type=std_logic lab=MACC[0..7]}
C {bus_tap.sym} 2170 -2730 1 0 {name=l64 lab=4}
C {bus_tap.sym} 2460 -2730 1 0 {name=l65 lab=5}
C {bus_tap.sym} 2750 -2730 1 0 {name=l66 lab=6}
C {bus_tap.sym} 3040 -2730 1 0 {name=l67 lab=7}
