v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {logic gates/nand4.sym} 720 -100 0 0 {name=x1}
C {lab_pin.sym} 90 -210 0 0 {name=p1 sig_type=std_logic lab=I[8..0]}
C {iopin.sym} 90 -210 0 0 {name=p2 lab=I[8..0]}
C {lab_pin.sym} 90 -180 0 0 {name=p3 sig_type=std_logic lab=Y[2..0]}
C {iopin.sym} 90 -180 0 0 {name=p4 lab=Y[2..0]}
C {lab_pin.sym} 90 -240 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {iopin.sym} 90 -240 0 0 {name=p6 lab=VSS}
C {lab_pin.sym} 90 -260 0 0 {name=p7 sig_type=std_logic lab=VCC}
C {iopin.sym} 90 -260 0 0 {name=p8 lab=VCC}
C {lab_pin.sym} 720 -130 0 1 {name=p9 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 720 -70 0 1 {name=p10 sig_type=std_logic lab=VSS}
C {logic gates/nand4.sym} 720 80 0 0 {name=x2}
C {lab_pin.sym} 720 50 0 1 {name=p11 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 720 110 0 1 {name=p12 sig_type=std_logic lab=VSS}
C {logic gates/nand4.sym} 720 260 0 0 {name=x3}
C {lab_pin.sym} 720 230 0 1 {name=p13 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 720 290 0 1 {name=p14 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 660 -160 0 0 {name=p15 sig_type=std_logic lab=D0}
C {lab_pin.sym} 660 -120 0 0 {name=p16 sig_type=std_logic lab=D1}
C {lab_pin.sym} 660 -80 0 0 {name=p17 sig_type=std_logic lab=D2}
C {lab_pin.sym} 660 -40 0 0 {name=p18 sig_type=std_logic lab=D3}
C {lab_pin.sym} 660 20 0 0 {name=p19 sig_type=std_logic lab=D0}
C {lab_pin.sym} 660 60 0 0 {name=p20 sig_type=std_logic lab=D1}
C {lab_pin.sym} 660 100 0 0 {name=p21 sig_type=std_logic lab=D4}
C {lab_pin.sym} 660 140 0 0 {name=p22 sig_type=std_logic lab=D5}
C {lab_pin.sym} 660 200 0 0 {name=p23 sig_type=std_logic lab=D1}
C {lab_pin.sym} 660 240 0 0 {name=p24 sig_type=std_logic lab=D3}
C {lab_pin.sym} 660 280 0 0 {name=p25 sig_type=std_logic lab=D5}
C {lab_pin.sym} 660 320 0 0 {name=p26 sig_type=std_logic lab=D7}
C {peripherals/priority_selector.sym} 350 50 0 0 {name=x4}
C {lab_pin.sym} 490 60 0 1 {name=p27 sig_type=std_logic lab=D[7..0]}
C {lab_pin.sym} 300 60 0 0 {name=p28 sig_type=std_logic lab=I[8..0]}
C {lab_pin.sym} 780 -100 0 1 {name=p29 sig_type=std_logic lab=Y2}
C {lab_pin.sym} 780 80 0 1 {name=p30 sig_type=std_logic lab=Y1}
C {lab_pin.sym} 780 260 0 1 {name=p31 sig_type=std_logic lab=Y0}
C {lab_pin.sym} 400 30 0 0 {name=p32 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 400 100 0 0 {name=p33 sig_type=std_logic lab=VSS}
