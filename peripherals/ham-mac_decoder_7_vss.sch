v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_pin.sym} 940 -3060 0 1 {name=p9 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1230 -3060 0 1 {name=p10 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1520 -3060 0 1 {name=p11 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1810 -3060 0 1 {name=p12 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2100 -3060 0 1 {name=p13 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2390 -3060 0 1 {name=p14 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2680 -3060 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2970 -3060 0 1 {name=p16 sig_type=std_logic lab=VSS}
