v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -980 -2270 -180 -1870 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=-1.3376882e-10
x2=1.6024913e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/mac_logic_gates.raw
autoload=0
digital=1
legend=1
color="4 5 6 7 8 9 10 11"
node="x1.q
x10.q
x5.q
x9.q
x21.q
x25.q
x33.q
x37.q"}
B 2 -990 -4080 -190 -3680 {flags=graph
y1=-0.027
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=-1.3376882e-10
x2=1.6024913e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/mac_logic_gates.raw
autoload=0
digital=1
color="4 5 6 7 8 9"
node="en
s2
s1
s0
rwl
pre"}
B 2 -1810 -3140 -1010 -2740 {flags=graph
y1=-0.027
y2=1.9
ypos1=0.45475
ypos2=2.38175
divy=5
subdivy=1
unity=1
x1=-1.3376882e-10
x2=1.6024913e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/mac_logic_gates.raw
autoload=0
digital=1
color="4 5 4 4 4 4 4 4 4"
node="wl8
wl7
wl6
wl5
wl4
wl3
wl2
wl1
wl0"}
B 2 -980 -2690 -180 -2290 {flags=graph
y1=-0.095
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=-1.3376882e-10
x2=1.6024913e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/mac_logic_gates.raw
autoload=0
digital=0
color="4 18 12 12 12 12 12 12 12 12 19 19 19 19 19 19 19 19 19"
node="rbl0

clk
mac8
mac7
mac6
mac5
mac4
mac3
mac2
mac1
mac0


tr7
tr6
tr5
tr4
tr3
tr2
tr1
tr0"
hilight_wave=1}
B 2 -980 -3150 -180 -2750 {flags=graph
y1=-0.095
y2=1.9
ypos1=-0.027
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=-1.3376882e-10
x2=1.6024913e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
rawfile=$netlist_dir/mac_logic_gates.raw
autoload=0
digital=0
hilight_wave=3
color="4 8 6 7"
node="or
xor
xnor
nand"}
N 850 -2250 3120 -2250 {lab=BL[0..7]
bus=true}
N 850 -2200 3120 -2200 {lab=BLB[0..7]
bus=true}
N 880 -2190 880 -2080 {lab=BLB0}
N 880 -2080 940 -2080 {lab=BLB0}
N 860 -2240 860 -2060 {lab=BL0
bus}
N 860 -2060 940 -2060 {lab=BL0}
N 200 -1670 200 -1480 {lab=WL[0..7]
bus=true}
N 150 -1640 190 -1640 {lab=WL7}
N 150 -1620 190 -1620 {lab=WL6}
N 150 -1600 190 -1600 {lab=WL5}
N 150 -1580 190 -1580 {lab=WL4}
N 150 -1560 190 -1560 {lab=WL3}
N 150 -1540 190 -1540 {lab=WL2}
N 150 -1520 190 -1520 {lab=WL1}
N 150 -1500 190 -1500 {lab=WL0}
N 860 -2060 860 -1810 {lab=BL0}
N 860 -1810 940 -1810 {lab=BL0}
N 880 -2080 880 -1830 {lab=BLB0}
N 880 -1830 940 -1830 {lab=BLB0}
N 860 -1810 860 -1560 {lab=BL0}
N 860 -1560 940 -1560 {lab=BL0}
N 880 -1830 880 -1580 {lab=BLB0}
N 880 -1580 940 -1580 {lab=BLB0}
N 860 -1560 860 -1310 {lab=BL0}
N 860 -1310 940 -1310 {lab=BL0}
N 880 -1580 880 -1330 {lab=BLB0}
N 880 -1330 940 -1330 {lab=BLB0}
N 860 -1310 860 -1060 {lab=BL0}
N 860 -1060 940 -1060 {lab=BL0}
N 880 -1330 880 -1080 {lab=BLB0}
N 880 -1080 940 -1080 {lab=BLB0}
N 860 -1060 860 -810 {lab=BL0}
N 860 -810 940 -810 {lab=BL0}
N 880 -1080 880 -830 {lab=BLB0}
N 880 -830 940 -830 {lab=BLB0}
N 860 -810 860 -560 {lab=BL0}
N 860 -560 940 -560 {lab=BL0}
N 880 -830 880 -580 {lab=BLB0}
N 880 -580 940 -580 {lab=BLB0}
N 860 -560 860 -310 {lab=BL0}
N 860 -310 940 -310 {lab=BL0}
N 880 -580 880 -330 {lab=BLB0}
N 880 -330 940 -330 {lab=BLB0}
N 730 -2140 730 -200 {lab=WL[0..7]}
N 1420 -2850 1420 -2470 {lab=MAC[8..0]}
N 1430 -2740 1560 -2740 {lab=MAC6}
N 1560 -2740 1600 -2740 {lab=MAC6}
N 1430 -2580 1550 -2580 {lab=MAC2}
N 1550 -2660 1550 -2580 {lab=MAC2}
N 1550 -2660 1600 -2660 {lab=MAC2}
N 1570 -2620 1600 -2620 {lab=MAC0}
N 1720 -2680 1890 -2680 {lab=XOR}
N 1430 -2500 1890 -2500 {lab=MAC0}
N 1560 -2700 1600 -2700 {lab=MAC4}
N 1570 -2620 1570 -2500 {lab=MAC0}
N 1430 -2660 1530 -2660 {lab=MAC4}
N 1530 -2700 1530 -2660 {lab=MAC4}
N 1530 -2700 1560 -2700 {lab=MAC4}
N 1430 -2820 1740 -2820 {lab=MAC8}
N 1760 -2600 1770 -2600 {lab=XOR}
N 1760 -2680 1760 -2600 {lab=XOR}
N 1740 -2820 1890 -2820 {lab=MAC8}
N 1760 -2760 1770 -2760 {lab=MAC8}
N 1760 -2820 1760 -2760 {lab=MAC8}
N 1760 -2430 1770 -2430 {lab=MAC0}
N 1760 -2500 1760 -2430 {lab=MAC0}
N 1230 -2850 1420 -2850 {lab=MAC[8..0]}
N 940 -3210 940 -3120 {lab=RBL0}
N 940 -3150 990 -3150 {lab=RBL0}
N 940 -3290 940 -3270 {lab=GND}
N 940 -3240 950 -3240 {lab=GND}
N 950 -3280 950 -3240 {lab=GND}
N 940 -3280 950 -3280 {lab=GND}
N 880 -3240 900 -3240 {lab=PRE}
N 990 -2850 1230 -2850 {lab=MAC[8..0]}
N 1180 -2880 1180 -2850 {lab=MAC[8..0]}
C {iopin.sym} 110 -2040 0 0 {name=p7 lab=WL[0..7]}
C {lab_pin.sym} 110 -2040 0 0 {name=p18 sig_type=std_logic lab=WL[0..7]}
C {lab_pin.sym} 940 -2100 0 0 {name=p1 sig_type=std_logic lab=WL0}
C {lab_pin.sym} 940 -2000 0 0 {name=p43 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -2120 0 0 {name=p51 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -1950 0 0 {name=p69 lab=S2}
C {iopin.sym} 110 -1930 0 0 {name=p70 lab=S1}
C {iopin.sym} 110 -1910 0 0 {name=p71 lab=S0}
C {lab_pin.sym} 110 -1950 0 0 {name=p72 sig_type=std_logic lab=S2}
C {lab_pin.sym} 110 -1930 0 0 {name=p73 sig_type=std_logic lab=S1}
C {lab_pin.sym} 110 -1910 0 0 {name=p74 sig_type=std_logic lab=S0}
C {iopin.sym} 110 -2310 0 0 {name=p78 lab=VCC}
C {iopin.sym} 110 -2290 0 0 {name=p79 lab=VSS}
C {lab_pin.sym} 110 -2290 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 110 -2310 0 0 {name=p81 sig_type=std_logic lab=VCC}
C {iopin.sym} 110 -2150 0 0 {name=p82 lab=EN}
C {lab_pin.sym} 110 -2150 0 0 {name=p83 sig_type=std_logic lab=EN}
C {lab_pin.sym} 940 -2020 0 0 {name=p87 sig_type=std_logic lab=RWL}
C {iopin.sym} 110 -1880 0 0 {name=p89 lab=RBL[0..7]}
C {iopin.sym} 110 -1860 0 0 {name=p90 lab=RWL}
C {lab_pin.sym} 110 -1880 0 0 {name=p91 sig_type=std_logic lab=RBL[0..7]}
C {lab_pin.sym} 110 -1860 0 0 {name=p92 sig_type=std_logic lab=RWL}
C {iopin.sym} 110 -1840 0 0 {name=p93 lab=PRE}
C {lab_pin.sym} 110 -1840 0 0 {name=p95 sig_type=std_logic lab=PRE}
C {8T_sram_cell_c.sym} 1090 -2060 0 1 {name=x1}
C {lab_pin.sym} 940 -2040 0 0 {name=p112 sig_type=std_logic lab=RBL0}
C {iopin.sym} 110 -2010 0 0 {name=p17 lab=BL[0..7]}
C {lab_pin.sym} 110 -2010 0 0 {name=p26 sig_type=std_logic lab=BL[0..7]}
C {iopin.sym} 110 -1990 0 0 {name=p59 lab=BLB[0..7]}
C {lab_pin.sym} 110 -1990 0 0 {name=p60 sig_type=std_logic lab=BLB[0..7]}
C {logic gates/decoder.sym} 100 -1570 0 0 {name=x77}
C {lab_pin.sym} 40 -1590 0 0 {name=p75 sig_type=std_logic lab=S2}
C {lab_pin.sym} 40 -1570 0 0 {name=p76 sig_type=std_logic lab=S1}
C {lab_pin.sym} 40 -1550 0 0 {name=p77 sig_type=std_logic lab=S0}
C {lab_pin.sym} 40 -1520 0 0 {name=p84 sig_type=std_logic lab=EN}
C {lab_pin.sym} 100 -1660 0 0 {name=p85 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 100 -1480 0 0 {name=p86 sig_type=std_logic lab=VSS}
C {bus_tap.sym} 850 -2250 1 0 {name=l2 lab=0}
C {lab_pin.sym} 850 -2250 0 0 {name=p3 sig_type=std_logic lab=BL[0..7]}
C {lab_pin.sym} 850 -2200 0 0 {name=p4 sig_type=std_logic lab=BLB[0..7]}
C {bus_tap.sym} 870 -2200 1 0 {name=l3 lab=0}
C {lab_pin.sym} 200 -1670 0 1 {name=p8 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 200 -1590 3 1 {name=l21 lab=4}
C {bus_tap.sym} 200 -1570 3 1 {name=l22 lab=3}
C {bus_tap.sym} 200 -1550 3 1 {name=l23 lab=2}
C {bus_tap.sym} 200 -1510 3 1 {name=l24 lab=0}
C {bus_tap.sym} 200 -1530 3 1 {name=l25 lab=1}
C {bus_tap.sym} 200 -1610 3 1 {name=l19 lab=5}
C {bus_tap.sym} 200 -1630 3 1 {name=l20 lab=6}
C {bus_tap.sym} 200 -1650 3 1 {name=l26 lab=7}
C {lab_pin.sym} 940 -1750 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1770 0 0 {name=p10 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -1810 0 1 {name=x10}
C {lab_pin.sym} 940 -1870 0 0 {name=p62 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1850 0 0 {name=p107 sig_type=std_logic lab=WL1}
C {iopin.sym} 110 -2100 0 0 {name=p131 lab=CLK}
C {lab_pin.sym} 110 -2100 0 0 {name=p132 sig_type=std_logic lab=CLK}
C {iopin.sym} 110 -2080 0 0 {name=p133 lab=CLK_bar}
C {lab_pin.sym} 110 -2080 0 0 {name=p134 sig_type=std_logic lab=CLK_bar}
C {iopin.sym} 110 -2130 0 0 {name=p135 lab=EN_bar}
C {lab_pin.sym} 110 -2130 0 0 {name=p136 lab=EN_bar}
C {lab_pin.sym} 110 -1810 0 0 {name=p145 sig_type=std_logic lab=TR[0..7]}
C {iopin.sym} 110 -1810 0 0 {name=p146 lab=TR[0..7]}
C {lab_pin.sym} 940 -1790 0 0 {name=p50 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 110 -1790 0 0 {name=p210 sig_type=std_logic lab=MAC[0..7]}
C {iopin.sym} 110 -1790 0 0 {name=p211 lab=MAC[0..7]}
C {iopin.sym} 110 -1770 0 0 {name=p212 lab=MACRBL}
C {lab_pin.sym} 110 -1770 0 0 {name=p213 sig_type=std_logic lab=MACRBL}
C {iopin.sym} 110 -1750 0 0 {name=p254 lab=MACRWL}
C {lab_pin.sym} 110 -1750 0 0 {name=p255 sig_type=std_logic lab=MACRWL}
C {iopin.sym} 110 -2200 0 0 {name=p281 lab=MAC_EN}
C {lab_pin.sym} 110 -2200 0 0 {name=p282 sig_type=std_logic lab=MAC_EN}
C {iopin.sym} 110 -2180 0 0 {name=p283 lab=MAC_EN_bar}
C {lab_pin.sym} 110 -2180 0 0 {name=p284 lab=MAC_EN_bar}
C {lab_pin.sym} 940 -1500 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1520 0 0 {name=p14 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -1560 0 1 {name=x5}
C {lab_pin.sym} 940 -1620 0 0 {name=p34 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1600 0 0 {name=p44 sig_type=std_logic lab=WL2}
C {lab_pin.sym} 940 -1540 0 0 {name=p55 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1250 0 0 {name=p56 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1270 0 0 {name=p57 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -1310 0 1 {name=x9}
C {lab_pin.sym} 940 -1370 0 0 {name=p97 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1350 0 0 {name=p102 sig_type=std_logic lab=WL3}
C {lab_pin.sym} 940 -1290 0 0 {name=p115 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -1000 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -1020 0 0 {name=p117 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -1060 0 1 {name=x21}
C {lab_pin.sym} 940 -1120 0 0 {name=p130 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -1100 0 0 {name=p149 sig_type=std_logic lab=WL4}
C {lab_pin.sym} 940 -1040 0 0 {name=p175 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -750 0 0 {name=p176 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -770 0 0 {name=p177 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -810 0 1 {name=x25}
C {lab_pin.sym} 940 -870 0 0 {name=p185 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -850 0 0 {name=p189 sig_type=std_logic lab=WL5}
C {lab_pin.sym} 940 -790 0 0 {name=p197 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -500 0 0 {name=p198 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -520 0 0 {name=p199 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -560 0 1 {name=x33}
C {lab_pin.sym} 940 -620 0 0 {name=p207 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -600 0 0 {name=p223 sig_type=std_logic lab=WL6}
C {lab_pin.sym} 940 -540 0 0 {name=p234 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 940 -250 0 0 {name=p235 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 940 -270 0 0 {name=p236 sig_type=std_logic lab=RWL}
C {8T_sram_cell_c.sym} 1090 -310 0 1 {name=x37}
C {lab_pin.sym} 940 -370 0 0 {name=p247 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 940 -350 0 0 {name=p259 sig_type=std_logic lab=WL7}
C {lab_pin.sym} 940 -290 0 0 {name=p266 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 730 -2140 0 0 {name=p443 sig_type=std_logic lab=WL[0..7]}
C {bus_tap.sym} 730 -360 1 0 {name=l33 lab=7}
C {bus_tap.sym} 1420 -2510 1 0 {name=l4 lab=0}
C {bus_tap.sym} 1420 -2550 1 0 {name=l5 lab=1}
C {bus_tap.sym} 1420 -2590 1 0 {name=l6 lab=2}
C {bus_tap.sym} 1420 -2630 1 0 {name=l7 lab=3}
C {bus_tap.sym} 1420 -2670 1 0 {name=l8 lab=4}
C {bus_tap.sym} 1420 -2710 1 0 {name=l9 lab=5}
C {bus_tap.sym} 1420 -2750 1 0 {name=l11 lab=6}
C {bus_tap.sym} 1420 -2790 1 0 {name=l12 lab=7}
C {bus_tap.sym} 1420 -2830 1 0 {name=l13 lab=8}
C {logic gates/nor4.sym} 1660 -2680 0 0 {name=x2}
C {lab_pin.sym} 1890 -2680 0 1 {name=p29 sig_type=std_logic lab=XOR}
C {lab_pin.sym} 1900 -2500 0 1 {name=p31 sig_type=std_logic lab=AND}
C {lab_pin.sym} 1660 -2710 0 1 {name=p38 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1660 -2650 0 1 {name=p39 sig_type=std_logic lab=VSS}
C {inv.sym} 1830 -2760 0 0 {name=x4}
C {lab_pin.sym} 1890 -2600 0 1 {name=p46 sig_type=std_logic lab=XNOR}
C {lab_pin.sym} 1890 -2760 0 1 {name=p47 sig_type=std_logic lab=OR}
C {lab_pin.sym} 1890 -2430 0 1 {name=p48 sig_type=std_logic lab=NAND}
C {inv.sym} 1830 -2600 0 0 {name=x3}
C {lab_pin.sym} 1900 -2820 0 1 {name=p30 sig_type=std_logic lab=NOR}
C {inv.sym} 1830 -2430 0 0 {name=x6}
C {lab_pin.sym} 1830 -2780 0 1 {name=p2 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1830 -2620 0 1 {name=p49 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1830 -2450 0 1 {name=p5 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 1830 -2740 0 1 {name=p6 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1830 -2580 0 1 {name=p52 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1830 -2410 0 1 {name=p53 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/cap_mim_m3_1.sym} 940 -3090 0 0 {name=C2 model=cap_mim_m3_1 W=27 L=1 MF=1 spiceprefix=X}
C {gnd.sym} 940 -3290 2 0 {name=l1 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 920 -3240 2 1 {name=M2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 940 -3060 0 1 {name=l10 lab=GND}
C {lab_pin.sym} 880 -3240 0 0 {name=p96 sig_type=std_logic lab=PRE}
C {lab_pin.sym} 990 -3150 0 1 {name=p128 sig_type=std_logic lab=RBL0}
C {voltage_comp/MAC_decoder_old.sym} 840 -2890 0 0 {name=x18}
C {lab_pin.sym} 990 -2950 0 1 {name=p139 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 990 -2970 0 1 {name=p140 sig_type=std_logic lab=VCC}
C {lab_pin.sym} 990 -2930 0 1 {name=p141 sig_type=std_logic lab=CLK}
C {lab_pin.sym} 990 -2910 0 1 {name=p142 sig_type=std_logic lab=CLK_bar}
C {lab_pin.sym} 1180 -2880 0 1 {name=p143 sig_type=std_logic lab=MAC[8..0]}
C {lab_pin.sym} 990 -2870 0 1 {name=p144 sig_type=std_logic lab=TR[7..0]}
C {lab_pin.sym} 990 -2890 0 1 {name=p201 sig_type=std_logic lab=RBL0}
C {lab_pin.sym} 990 -2810 0 1 {name=p285 sig_type=std_logic lab=MAC_EN_bar}
C {lab_pin.sym} 990 -2830 0 1 {name=p286 lab=MAC_EN}
C {iopin.sym} 120 -2470 0 1 {name=p21 lab=XOR}
C {lab_pin.sym} 120 -2470 0 1 {name=p22 sig_type=std_logic lab=XOR}
C {iopin.sym} 120 -2450 0 1 {name=p23 lab=NOR}
C {lab_pin.sym} 120 -2450 0 1 {name=p24 sig_type=std_logic lab=NOR}
C {iopin.sym} 120 -2430 0 1 {name=p25 lab=AND}
C {lab_pin.sym} 120 -2430 0 1 {name=p12 sig_type=std_logic lab=AND}
C {iopin.sym} 120 -2410 0 1 {name=p40 lab=XNOR}
C {lab_pin.sym} 120 -2410 0 1 {name=p41 sig_type=std_logic lab=XNOR}
C {iopin.sym} 120 -2390 0 1 {name=p42 lab=OR}
C {lab_pin.sym} 120 -2390 0 1 {name=p13 sig_type=std_logic lab=OR}
C {iopin.sym} 120 -2370 0 1 {name=p15 lab=NAND}
C {lab_pin.sym} 120 -2370 0 1 {name=p45 sig_type=std_logic lab=NAND}
C {code_shown.sym} -1200 -1890 0 0 {name=s2 only_toplevel=false spice_ignore=false value=
"
.param VCC=1.8 VSS=0

V_VCC VCC 0 DC 1.8
V_VSS VSS 0 DC 0
"}
C {code_shown.sym} -1200 -1750 0 0 {name=s5 only_toplevel=false value=
"
.param VSS=0 VCC=1.8 BL_period=3ns t_dly=1ns rise=10ps fall =10ps rwl_time=0.5ns pre_time=6ns clk_period=30ns

.include "/home/user/pyvenvs/sky130venv/spice_files/mac_logic_gates_code.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/thresholds.spice"
.save all

"}
C {code_shown.sym} -980 -1890 0 0 {name=s6 only_toplevel=false spice_ignore=false value=
"
*.include "/home/user/pyvenvs/sky130venv/nodeset.spice"
.include "/home/user/pyvenvs/sky130venv/spice_files/mac_logic_gate_sram.spice"
"}
C {code.sym} -1210 -2080 0 0 {
name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
"
spice_ignore=false
      }
C {launcher.sym} -1330 -3290 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/mac_logic_gates.raw tran"
}
